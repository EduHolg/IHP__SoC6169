v {xschem version=3.4.6 file_version=1.2
* Copyright 2026 USFQ CAM team
*
* Licensed under the Apache License, Version 2.0 (the "License");
* you may not use this file except in compliance with the License.
* You may obtain a copy of the License at
*
*     https://www.apache.org/licenses/LICENSE-2.0
*
* Unless required by applicable law or agreed to in writing, software
* distributed under the License is distributed on an "AS IS" BASIS,
* WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
* See the License for the specific language governing permissions and
* limitations under the License.
}
G {}
K {}
V {}
S {}
E {}
C {iopin.sym} -200 0 0 0 {name=p1 lab=VGND}
C {iopin.sym} -200 30 0 0 {name=p2 lab=VPWR}
C {ipin.sym} -200 60 0 0 {name=p3 lab=clk}
C {opin.sym} -200 90 0 0 {name=p4 lab=q[0]}
C {opin.sym} -200 120 0 0 {name=p5 lab=q[10]}
C {opin.sym} -200 150 0 0 {name=p6 lab=q[11]}
C {opin.sym} -200 180 0 0 {name=p7 lab=q[12]}
C {opin.sym} -200 210 0 0 {name=p8 lab=q[13]}
C {opin.sym} -200 240 0 0 {name=p9 lab=q[14]}
C {opin.sym} -200 270 0 0 {name=p10 lab=q[15]}
C {opin.sym} -200 300 0 0 {name=p11 lab=q[16]}
C {opin.sym} -200 330 0 0 {name=p12 lab=q[17]}
C {opin.sym} -200 360 0 0 {name=p13 lab=q[18]}
C {opin.sym} -200 390 0 0 {name=p14 lab=q[19]}
C {opin.sym} -200 420 0 0 {name=p15 lab=q[1]}
C {opin.sym} -200 450 0 0 {name=p16 lab=q[20]}
C {opin.sym} -200 480 0 0 {name=p17 lab=q[21]}
C {opin.sym} -200 510 0 0 {name=p18 lab=q[22]}
C {opin.sym} -200 540 0 0 {name=p19 lab=q[23]}
C {opin.sym} -200 570 0 0 {name=p20 lab=q[24]}
C {opin.sym} -200 600 0 0 {name=p21 lab=q[25]}
C {opin.sym} -200 630 0 0 {name=p22 lab=q[26]}
C {opin.sym} -200 660 0 0 {name=p23 lab=q[27]}
C {opin.sym} -200 690 0 0 {name=p24 lab=q[28]}
C {opin.sym} -200 720 0 0 {name=p25 lab=q[29]}
C {opin.sym} -200 750 0 0 {name=p26 lab=q[2]}
C {opin.sym} -200 780 0 0 {name=p27 lab=q[30]}
C {opin.sym} -200 810 0 0 {name=p28 lab=q[31]}
C {opin.sym} -200 840 0 0 {name=p29 lab=q[3]}
C {opin.sym} -200 870 0 0 {name=p30 lab=q[4]}
C {opin.sym} -200 900 0 0 {name=p31 lab=q[5]}
C {opin.sym} -200 930 0 0 {name=p32 lab=q[6]}
C {opin.sym} -200 960 0 0 {name=p33 lab=q[7]}
C {opin.sym} -200 990 0 0 {name=p34 lab=q[8]}
C {opin.sym} -200 1020 0 0 {name=p35 lab=q[9]}
C {opin.sym} -200 1050 0 0 {name=p36 lab=q_bar[0]}
C {opin.sym} -200 1080 0 0 {name=p37 lab=q_bar[10]}
C {opin.sym} -200 1110 0 0 {name=p38 lab=q_bar[11]}
C {opin.sym} -200 1140 0 0 {name=p39 lab=q_bar[12]}
C {opin.sym} -200 1170 0 0 {name=p40 lab=q_bar[13]}
C {opin.sym} -200 1200 0 0 {name=p41 lab=q_bar[14]}
C {opin.sym} -200 1230 0 0 {name=p42 lab=q_bar[15]}
C {opin.sym} -200 1260 0 0 {name=p43 lab=q_bar[16]}
C {opin.sym} -200 1290 0 0 {name=p44 lab=q_bar[17]}
C {opin.sym} -200 1320 0 0 {name=p45 lab=q_bar[18]}
C {opin.sym} -200 1350 0 0 {name=p46 lab=q_bar[19]}
C {opin.sym} -200 1380 0 0 {name=p47 lab=q_bar[1]}
C {opin.sym} -200 1410 0 0 {name=p48 lab=q_bar[20]}
C {opin.sym} -200 1440 0 0 {name=p49 lab=q_bar[21]}
C {opin.sym} -200 1470 0 0 {name=p50 lab=q_bar[22]}
C {opin.sym} -200 1500 0 0 {name=p51 lab=q_bar[23]}
C {opin.sym} -200 1530 0 0 {name=p52 lab=q_bar[24]}
C {opin.sym} -200 1560 0 0 {name=p53 lab=q_bar[25]}
C {opin.sym} -200 1590 0 0 {name=p54 lab=q_bar[26]}
C {opin.sym} -200 1620 0 0 {name=p55 lab=q_bar[27]}
C {opin.sym} -200 1650 0 0 {name=p56 lab=q_bar[28]}
C {opin.sym} -200 1680 0 0 {name=p57 lab=q_bar[29]}
C {opin.sym} -200 1710 0 0 {name=p58 lab=q_bar[2]}
C {opin.sym} -200 1740 0 0 {name=p59 lab=q_bar[30]}
C {opin.sym} -200 1770 0 0 {name=p60 lab=q_bar[31]}
C {opin.sym} -200 1800 0 0 {name=p61 lab=q_bar[3]}
C {opin.sym} -200 1830 0 0 {name=p62 lab=q_bar[4]}
C {opin.sym} -200 1860 0 0 {name=p63 lab=q_bar[5]}
C {opin.sym} -200 1890 0 0 {name=p64 lab=q_bar[6]}
C {opin.sym} -200 1920 0 0 {name=p65 lab=q_bar[7]}
C {opin.sym} -200 1950 0 0 {name=p66 lab=q_bar[8]}
C {opin.sym} -200 1980 0 0 {name=p67 lab=q_bar[9]}
C {ipin.sym} -200 2010 0 0 {name=p68 lab=reset}
C {ipin.sym} -200 2040 0 0 {name=p69 lab=serial_in_data}
C {ipin.sym} -200 2070 0 0 {name=p70 lab=shift_enable}
C {sg13cmos5l_dfrbpq_1.sym} 760 20 0 0 {name=X_277_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 0 630 0 {lab=clk}
C {lab_pin.sym} 630 0 0 0 {name=l78 sig_type=std_logic lab=clk}
N 670 20 630 20 {lab=_277__D}
C {lab_pin.sym} 630 20 0 0 {name=l80 sig_type=std_logic lab=_277__D}
N 670 40 630 40 {lab=_277__97_L_HI}
C {lab_pin.sym} 630 40 0 0 {name=l82 sig_type=std_logic lab=_277__97_L_HI}
N 850 0 890 0 {lab=_277__Q}
C {lab_pin.sym} 890 0 0 1 {name=l84 sig_type=std_logic lab=_277__Q}
C {sg13cmos5l_nor2_1.sym} 1350 20 0 0 {name=X_200_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 0 1250 0 {lab=_200__A}
C {lab_pin.sym} 1250 0 0 0 {name=l87 sig_type=std_logic lab=_200__A}
N 1290 40 1250 40 {lab=_202__A}
C {lab_pin.sym} 1250 40 0 0 {name=l89 sig_type=std_logic lab=_202__A}
N 1410 20 1450 20 {lab=_201__C}
C {lab_pin.sym} 1450 20 0 1 {name=l91 sig_type=std_logic lab=_201__C}
C {sg13cmos5l_inv_1.sym} 1950 0 0 0 {name=X_131_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 0 1870 0 {lab=_284__Q}
C {lab_pin.sym} 1870 0 0 0 {name=l94 sig_type=std_logic lab=_284__Q}
N 1990 0 2030 0 {lab=_131__Y}
C {lab_pin.sym} 2030 0 0 1 {name=l96 sig_type=std_logic lab=_131__Y}
C {sg13cmos5l_buf_1.sym} 2570 0 0 0 {name=Xoutput20 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 0 2490 0 {lab=_267__Q}
C {lab_pin.sym} 2490 0 0 0 {name=l99 sig_type=std_logic lab=_267__Q}
N 2610 0 2650 0 {lab=q[24]}
C {lab_pin.sym} 2650 0 0 1 {name=l101 sig_type=std_logic lab=q[24]}
C {sg13cmos5l_buf_1.sym} 3190 0 0 0 {name=Xoutput42 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 0 3110 0 {lab=_157__Y}
C {lab_pin.sym} 3110 0 0 0 {name=l104 sig_type=std_logic lab=_157__Y}
N 3230 0 3270 0 {lab=q_bar[15]}
C {lab_pin.sym} 3270 0 0 1 {name=l106 sig_type=std_logic lab=q_bar[15]}
C {sg13cmos5l_buf_1.sym} 3810 0 0 0 {name=Xoutput64 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 0 3730 0 {lab=_134__Y}
C {lab_pin.sym} 3730 0 0 0 {name=l109 sig_type=std_logic lab=_134__Y}
N 3850 0 3890 0 {lab=q_bar[6]}
C {lab_pin.sym} 3890 0 0 1 {name=l111 sig_type=std_logic lab=q_bar[6]}
C {sg13cmos5l_buf_1.sym} 4430 0 0 0 {name=Xoutput31 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 0 4350 0 {lab=_280__Q}
C {lab_pin.sym} 4350 0 0 0 {name=l114 sig_type=std_logic lab=_280__Q}
N 4470 0 4510 0 {lab=q[5]}
C {lab_pin.sym} 4510 0 0 1 {name=l116 sig_type=std_logic lab=q[5]}
C {sg13cmos5l_buf_1.sym} 5050 0 0 0 {name=Xoutput7 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 0 4970 0 {lab=_287__Q}
C {lab_pin.sym} 4970 0 0 0 {name=l119 sig_type=std_logic lab=_287__Q}
N 5090 0 5130 0 {lab=q[12]}
C {lab_pin.sym} 5130 0 0 1 {name=l121 sig_type=std_logic lab=q[12]}
C {sg13cmos5l_buf_1.sym} 5670 0 0 0 {name=Xoutput53 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 0 5590 0 {lab=_147__Y}
C {lab_pin.sym} 5590 0 0 0 {name=l124 sig_type=std_logic lab=_147__Y}
N 5710 0 5750 0 {lab=q_bar[25]}
C {lab_pin.sym} 5750 0 0 1 {name=l126 sig_type=std_logic lab=q_bar[25]}
C {sg13cmos5l_tiehi.sym} 6250 0 0 0 {name=X_270__88 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 0 6210 0 {lab=_270__88_L_HI}
C {lab_pin.sym} 6210 0 0 0 {name=l129 sig_type=std_logic lab=_270__88_L_HI}
C {sg13cmos5l_dlygate4sd3_1.sym} 6910 0 0 0 {name=Xhold160 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 0 6830 0 {lab=_162__Y}
C {lab_pin.sym} 6830 0 0 0 {name=l132 sig_type=std_logic lab=_162__Y}
N 6950 0 6990 0 {lab=_256__D}
C {lab_pin.sym} 6990 0 0 1 {name=l134 sig_type=std_logic lab=_256__D}
C {sg13cmos5l_dfrbpq_1.sym} 7580 20 0 0 {name=X_276_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 0 7450 0 {lab=clk}
C {lab_pin.sym} 7450 0 0 0 {name=l137 sig_type=std_logic lab=clk}
N 7490 20 7450 20 {lab=_276__D}
C {lab_pin.sym} 7450 20 0 0 {name=l139 sig_type=std_logic lab=_276__D}
N 7490 40 7450 40 {lab=_276__RESET_B}
C {lab_pin.sym} 7450 40 0 0 {name=l141 sig_type=std_logic lab=_276__RESET_B}
N 7670 0 7710 0 {lab=_276__Q}
C {lab_pin.sym} 7710 0 0 1 {name=l143 sig_type=std_logic lab=_276__Q}
C {sg13cmos5l_inv_1.sym} 710 160 0 0 {name=X_130_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 160 630 160 {lab=_285__Q}
C {lab_pin.sym} 630 160 0 0 {name=l146 sig_type=std_logic lab=_285__Q}
N 750 160 790 160 {lab=_130__Y}
C {lab_pin.sym} 790 160 0 1 {name=l148 sig_type=std_logic lab=_130__Y}
C {sg13cmos5l_dfrbpq_1.sym} 1380 180 0 0 {name=X_259_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 160 1250 160 {lab=clk}
C {lab_pin.sym} 1250 160 0 0 {name=l151 sig_type=std_logic lab=clk}
N 1290 180 1250 180 {lab=_259__D}
C {lab_pin.sym} 1250 180 0 0 {name=l153 sig_type=std_logic lab=_259__D}
N 1290 200 1250 200 {lab=_259__RESET_B}
C {lab_pin.sym} 1250 200 0 0 {name=l155 sig_type=std_logic lab=_259__RESET_B}
N 1470 160 1510 160 {lab=_259__Q}
C {lab_pin.sym} 1510 160 0 1 {name=l157 sig_type=std_logic lab=_259__Q}
C {sg13cmos5l_tiehi.sym} 1910 160 0 0 {name=X_267__94 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 160 1870 160 {lab=_267__94_L_HI}
C {lab_pin.sym} 1870 160 0 0 {name=l160 sig_type=std_logic lab=_267__94_L_HI}
C {sg13cmos5l_buf_1.sym} 2570 160 0 0 {name=Xoutput43 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 160 2490 160 {lab=_156__Y}
C {lab_pin.sym} 2490 160 0 0 {name=l163 sig_type=std_logic lab=_156__Y}
N 2610 160 2650 160 {lab=q_bar[16]}
C {lab_pin.sym} 2650 160 0 1 {name=l165 sig_type=std_logic lab=q_bar[16]}
C {sg13cmos5l_buf_1.sym} 3190 160 0 0 {name=Xoutput10 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 160 3110 160 {lab=_258__Q}
C {lab_pin.sym} 3110 160 0 0 {name=l168 sig_type=std_logic lab=_258__Q}
N 3230 160 3270 160 {lab=q[15]}
C {lab_pin.sym} 3270 160 0 1 {name=l170 sig_type=std_logic lab=q[15]}
C {sg13cmos5l_buf_1.sym} 3810 160 0 0 {name=Xoutput8 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 160 3730 160 {lab=_256__Q}
C {lab_pin.sym} 3730 160 0 0 {name=l173 sig_type=std_logic lab=_256__Q}
N 3850 160 3890 160 {lab=q[13]}
C {lab_pin.sym} 3890 160 0 1 {name=l175 sig_type=std_logic lab=q[13]}
C {sg13cmos5l_buf_1.sym} 4430 160 0 0 {name=Xoutput65 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 160 4350 160 {lab=_133__Y}
C {lab_pin.sym} 4350 160 0 0 {name=l178 sig_type=std_logic lab=_133__Y}
N 4470 160 4510 160 {lab=q_bar[7]}
C {lab_pin.sym} 4510 160 0 1 {name=l180 sig_type=std_logic lab=q_bar[7]}
C {sg13cmos5l_buf_1.sym} 5050 160 0 0 {name=Xoutput32 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 160 4970 160 {lab=_281__Q}
C {lab_pin.sym} 4970 160 0 0 {name=l183 sig_type=std_logic lab=_281__Q}
N 5090 160 5130 160 {lab=q[6]}
C {lab_pin.sym} 5130 160 0 1 {name=l185 sig_type=std_logic lab=q[6]}
C {sg13cmos5l_buf_1.sym} 5670 160 0 0 {name=Xoutput21 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 160 5590 160 {lab=_268__Q}
C {lab_pin.sym} 5590 160 0 0 {name=l188 sig_type=std_logic lab=_268__Q}
N 5710 160 5750 160 {lab=q[25]}
C {lab_pin.sym} 5750 160 0 1 {name=l190 sig_type=std_logic lab=q[25]}
C {sg13cmos5l_buf_1.sym} 6290 160 0 0 {name=Xoutput54 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 160 6210 160 {lab=_146__Y}
C {lab_pin.sym} 6210 160 0 0 {name=l193 sig_type=std_logic lab=_146__Y}
N 6330 160 6370 160 {lab=q_bar[26]}
C {lab_pin.sym} 6370 160 0 1 {name=l195 sig_type=std_logic lab=q_bar[26]}
C {sg13cmos5l_dlygate4sd3_1.sym} 6910 160 0 0 {name=Xhold161 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 160 6830 160 {lab=_268__Q}
C {lab_pin.sym} 6830 160 0 0 {name=l198 sig_type=std_logic lab=_268__Q}
N 6950 160 6990 160 {lab=_197__B}
C {lab_pin.sym} 6990 160 0 1 {name=l200 sig_type=std_logic lab=_197__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 7530 160 0 0 {name=Xhold150 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 160 7450 160 {lab=_255__Y}
C {lab_pin.sym} 7450 160 0 0 {name=l203 sig_type=std_logic lab=_255__Y}
N 7570 160 7610 160 {lab=_287__D}
C {lab_pin.sym} 7610 160 0 1 {name=l205 sig_type=std_logic lab=_287__D}
C {sg13cmos5l_dfrbpq_1.sym} 760 340 0 0 {name=X_275_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 320 630 320 {lab=clk}
C {lab_pin.sym} 630 320 0 0 {name=l208 sig_type=std_logic lab=clk}
N 670 340 630 340 {lab=_275__D}
C {lab_pin.sym} 630 340 0 0 {name=l210 sig_type=std_logic lab=_275__D}
N 670 360 630 360 {lab=_275__RESET_B}
C {lab_pin.sym} 630 360 0 0 {name=l212 sig_type=std_logic lab=_275__RESET_B}
N 850 320 890 320 {lab=_275__Q}
C {lab_pin.sym} 890 320 0 1 {name=l214 sig_type=std_logic lab=_275__Q}
C {sg13cmos5l_dfrbpq_1.sym} 1380 340 0 0 {name=X_258_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 320 1250 320 {lab=clk}
C {lab_pin.sym} 1250 320 0 0 {name=l217 sig_type=std_logic lab=clk}
N 1290 340 1250 340 {lab=_258__D}
C {lab_pin.sym} 1250 340 0 0 {name=l219 sig_type=std_logic lab=_258__D}
N 1290 360 1250 360 {lab=_258__RESET_B}
C {lab_pin.sym} 1250 360 0 0 {name=l221 sig_type=std_logic lab=_258__RESET_B}
N 1470 320 1510 320 {lab=_258__Q}
C {lab_pin.sym} 1510 320 0 1 {name=l223 sig_type=std_logic lab=_258__Q}
C {sg13cmos5l_nor3_1.sym} 1970 360 0 0 {name=X_189_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 320 1870 320 {lab=_195__A}
C {lab_pin.sym} 1870 320 0 0 {name=l226 sig_type=std_logic lab=_195__A}
N 1910 360 1870 360 {lab=_189__B}
C {lab_pin.sym} 1870 360 0 0 {name=l228 sig_type=std_logic lab=_189__B}
N 1910 400 1870 400 {lab=_189__C}
C {lab_pin.sym} 1870 400 0 0 {name=l230 sig_type=std_logic lab=_189__C}
N 2030 360 2070 360 {lab=_265__D}
C {lab_pin.sym} 2070 360 0 1 {name=l232 sig_type=std_logic lab=_265__D}
C {sg13cmos5l_buf_1.sym} 2570 320 0 0 {name=Xoutput22 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 320 2490 320 {lab=_269__Q}
C {lab_pin.sym} 2490 320 0 0 {name=l235 sig_type=std_logic lab=_269__Q}
N 2610 320 2650 320 {lab=q[26]}
C {lab_pin.sym} 2650 320 0 1 {name=l237 sig_type=std_logic lab=q[26]}
C {sg13cmos5l_buf_1.sym} 3190 320 0 0 {name=Xoutput44 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 320 3110 320 {lab=_155__Y}
C {lab_pin.sym} 3110 320 0 0 {name=l240 sig_type=std_logic lab=_155__Y}
N 3230 320 3270 320 {lab=q_bar[17]}
C {lab_pin.sym} 3270 320 0 1 {name=l242 sig_type=std_logic lab=q_bar[17]}
C {sg13cmos5l_buf_1.sym} 3810 320 0 0 {name=Xoutput11 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 320 3730 320 {lab=_259__Q}
C {lab_pin.sym} 3730 320 0 0 {name=l245 sig_type=std_logic lab=_259__Q}
N 3850 320 3890 320 {lab=q[16]}
C {lab_pin.sym} 3890 320 0 1 {name=l247 sig_type=std_logic lab=q[16]}
C {sg13cmos5l_buf_1.sym} 4430 320 0 0 {name=Xoutput9 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 320 4350 320 {lab=_257__Q}
C {lab_pin.sym} 4350 320 0 0 {name=l250 sig_type=std_logic lab=_257__Q}
N 4470 320 4510 320 {lab=q[14]}
C {lab_pin.sym} 4510 320 0 1 {name=l252 sig_type=std_logic lab=q[14]}
C {sg13cmos5l_buf_1.sym} 5050 320 0 0 {name=Xoutput33 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 320 4970 320 {lab=_282__Q}
C {lab_pin.sym} 4970 320 0 0 {name=l255 sig_type=std_logic lab=_282__Q}
N 5090 320 5130 320 {lab=q[7]}
C {lab_pin.sym} 5130 320 0 1 {name=l257 sig_type=std_logic lab=q[7]}
C {sg13cmos5l_buf_1.sym} 5670 320 0 0 {name=Xoutput66 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 320 5590 320 {lab=_132__Y}
C {lab_pin.sym} 5590 320 0 0 {name=l260 sig_type=std_logic lab=_132__Y}
N 5710 320 5750 320 {lab=q_bar[8]}
C {lab_pin.sym} 5750 320 0 1 {name=l262 sig_type=std_logic lab=q_bar[8]}
C {sg13cmos5l_buf_1.sym} 6290 320 0 0 {name=Xoutput55 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 320 6210 320 {lab=_145__Y}
C {lab_pin.sym} 6210 320 0 0 {name=l265 sig_type=std_logic lab=_145__Y}
N 6330 320 6370 320 {lab=q_bar[27]}
C {lab_pin.sym} 6370 320 0 1 {name=l267 sig_type=std_logic lab=q_bar[27]}
C {sg13cmos5l_dlygate4sd3_1.sym} 6910 320 0 0 {name=Xhold140 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 320 6830 320 {lab=_262__Q}
C {lab_pin.sym} 6830 320 0 0 {name=l270 sig_type=std_logic lab=_262__Q}
N 6950 320 6990 320 {lab=_181__A}
C {lab_pin.sym} 6990 320 0 1 {name=l272 sig_type=std_logic lab=_181__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 7530 320 0 0 {name=Xhold151 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 320 7450 320 {lab=_263__Q}
C {lab_pin.sym} 7450 320 0 0 {name=l275 sig_type=std_logic lab=_263__Q}
N 7570 320 7610 320 {lab=_182__B}
C {lab_pin.sym} 7610 320 0 1 {name=l277 sig_type=std_logic lab=_182__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 710 480 0 0 {name=Xhold162 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 480 630 480 {lab=_266__Q}
C {lab_pin.sym} 630 480 0 0 {name=l280 sig_type=std_logic lab=_266__Q}
N 750 480 790 480 {lab=_191__B}
C {lab_pin.sym} 790 480 0 1 {name=l282 sig_type=std_logic lab=_191__B}
C {sg13cmos5l_dfrbpq_1.sym} 1380 500 0 0 {name=X_274_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 480 1250 480 {lab=clk}
C {lab_pin.sym} 1250 480 0 0 {name=l285 sig_type=std_logic lab=clk}
N 1290 500 1250 500 {lab=_274__D}
C {lab_pin.sym} 1250 500 0 0 {name=l287 sig_type=std_logic lab=_274__D}
N 1290 520 1250 520 {lab=_274__RESET_B}
C {lab_pin.sym} 1250 520 0 0 {name=l289 sig_type=std_logic lab=_274__RESET_B}
N 1470 480 1510 480 {lab=_274__Q}
C {lab_pin.sym} 1510 480 0 1 {name=l291 sig_type=std_logic lab=_274__Q}
C {sg13cmos5l_tiehi.sym} 1910 480 0 0 {name=X_264__100 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 480 1870 480 {lab=_264__RESET_B}
C {lab_pin.sym} 1870 480 0 0 {name=l294 sig_type=std_logic lab=_264__RESET_B}
C {sg13cmos5l_dfrbpq_1.sym} 2620 500 0 0 {name=X_257_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 480 2490 480 {lab=clk}
C {lab_pin.sym} 2490 480 0 0 {name=l297 sig_type=std_logic lab=clk}
N 2530 500 2490 500 {lab=_257__D}
C {lab_pin.sym} 2490 500 0 0 {name=l299 sig_type=std_logic lab=_257__D}
N 2530 520 2490 520 {lab=_257__RESET_B}
C {lab_pin.sym} 2490 520 0 0 {name=l301 sig_type=std_logic lab=_257__RESET_B}
N 2710 480 2750 480 {lab=_257__Q}
C {lab_pin.sym} 2750 480 0 1 {name=l303 sig_type=std_logic lab=_257__Q}
C {sg13cmos5l_nor2_1.sym} 3210 500 0 0 {name=X_188_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 480 3110 480 {lab=_191__A}
C {lab_pin.sym} 3110 480 0 0 {name=l306 sig_type=std_logic lab=_191__A}
N 3150 520 3110 520 {lab=_190__A}
C {lab_pin.sym} 3110 520 0 0 {name=l308 sig_type=std_logic lab=_190__A}
N 3270 500 3310 500 {lab=_189__C}
C {lab_pin.sym} 3310 500 0 1 {name=l310 sig_type=std_logic lab=_189__C}
C {sg13cmos5l_buf_1.sym} 3810 480 0 0 {name=Xoutput56 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 480 3730 480 {lab=_144__Y}
C {lab_pin.sym} 3730 480 0 0 {name=l313 sig_type=std_logic lab=_144__Y}
N 3850 480 3890 480 {lab=q_bar[28]}
C {lab_pin.sym} 3890 480 0 1 {name=l315 sig_type=std_logic lab=q_bar[28]}
C {sg13cmos5l_buf_1.sym} 4430 480 0 0 {name=Xoutput45 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 480 4350 480 {lab=_154__Y}
C {lab_pin.sym} 4350 480 0 0 {name=l318 sig_type=std_logic lab=_154__Y}
N 4470 480 4510 480 {lab=q_bar[18]}
C {lab_pin.sym} 4510 480 0 1 {name=l320 sig_type=std_logic lab=q_bar[18]}
C {sg13cmos5l_buf_1.sym} 5050 480 0 0 {name=Xoutput12 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 480 4970 480 {lab=_260__Q}
C {lab_pin.sym} 4970 480 0 0 {name=l323 sig_type=std_logic lab=_260__Q}
N 5090 480 5130 480 {lab=q[17]}
C {lab_pin.sym} 5130 480 0 1 {name=l325 sig_type=std_logic lab=q[17]}
C {sg13cmos5l_buf_1.sym} 5670 480 0 0 {name=Xoutput67 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 480 5590 480 {lab=_131__Y}
C {lab_pin.sym} 5590 480 0 0 {name=l328 sig_type=std_logic lab=_131__Y}
N 5710 480 5750 480 {lab=q_bar[9]}
C {lab_pin.sym} 5750 480 0 1 {name=l330 sig_type=std_logic lab=q_bar[9]}
C {sg13cmos5l_buf_1.sym} 6290 480 0 0 {name=Xoutput34 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 480 6210 480 {lab=_283__Q}
C {lab_pin.sym} 6210 480 0 0 {name=l333 sig_type=std_logic lab=_283__Q}
N 6330 480 6370 480 {lab=q[8]}
C {lab_pin.sym} 6370 480 0 1 {name=l335 sig_type=std_logic lab=q[8]}
C {sg13cmos5l_buf_1.sym} 6910 480 0 0 {name=Xoutput23 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 480 6830 480 {lab=_270__Q}
C {lab_pin.sym} 6830 480 0 0 {name=l338 sig_type=std_logic lab=_270__Q}
N 6950 480 6990 480 {lab=q[27]}
C {lab_pin.sym} 6990 480 0 1 {name=l340 sig_type=std_logic lab=q[27]}
C {sg13cmos5l_dlygate4sd3_1.sym} 7530 480 0 0 {name=Xhold141 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 480 7450 480 {lab=_279__Q}
C {lab_pin.sym} 7450 480 0 0 {name=l343 sig_type=std_logic lab=_279__Q}
N 7570 480 7610 480 {lab=_230__B}
C {lab_pin.sym} 7610 480 0 1 {name=l345 sig_type=std_logic lab=_230__B}
C {sg13cmos5l_dfrbpq_1.sym} 760 660 0 0 {name=X_273_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 640 630 640 {lab=clk}
C {lab_pin.sym} 630 640 0 0 {name=l348 sig_type=std_logic lab=clk}
N 670 660 630 660 {lab=_273__D}
C {lab_pin.sym} 630 660 0 0 {name=l350 sig_type=std_logic lab=_273__D}
N 670 680 630 680 {lab=_273__RESET_B}
C {lab_pin.sym} 630 680 0 0 {name=l352 sig_type=std_logic lab=_273__RESET_B}
N 850 640 890 640 {lab=_273__Q}
C {lab_pin.sym} 890 640 0 1 {name=l354 sig_type=std_logic lab=_273__Q}
C {sg13cmos5l_dlygate4sd3_1.sym} 1330 640 0 0 {name=Xhold130 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 640 1250 640 {lab=_283__Q}
C {lab_pin.sym} 1250 640 0 0 {name=l357 sig_type=std_logic lab=_283__Q}
N 1370 640 1410 640 {lab=_244__A}
C {lab_pin.sym} 1410 640 0 1 {name=l359 sig_type=std_logic lab=_244__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 1950 640 0 0 {name=Xhold152 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 640 1870 640 {lab=_265__Q}
C {lab_pin.sym} 1870 640 0 0 {name=l362 sig_type=std_logic lab=_265__Q}
N 1990 640 2030 640 {lab=_190__A}
C {lab_pin.sym} 2030 640 0 1 {name=l364 sig_type=std_logic lab=_190__A}
C {sg13cmos5l_nor2b_1.sym} 2590 660 0 0 {name=X_187_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 640 2490 640 {lab=_187__A}
C {lab_pin.sym} 2490 640 0 0 {name=l367 sig_type=std_logic lab=_187__A}
N 2530 680 2490 680 {lab=_191__A}
C {lab_pin.sym} 2490 680 0 0 {name=l369 sig_type=std_logic lab=_191__A}
N 2650 660 2690 660 {lab=_189__B}
C {lab_pin.sym} 2690 660 0 1 {name=l371 sig_type=std_logic lab=_189__B}
C {sg13cmos5l_dfrbpq_1.sym} 3240 660 0 0 {name=X_256_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 640 3110 640 {lab=clk}
C {lab_pin.sym} 3110 640 0 0 {name=l374 sig_type=std_logic lab=clk}
N 3150 660 3110 660 {lab=_256__D}
C {lab_pin.sym} 3110 660 0 0 {name=l376 sig_type=std_logic lab=_256__D}
N 3150 680 3110 680 {lab=_256__RESET_B}
C {lab_pin.sym} 3110 680 0 0 {name=l378 sig_type=std_logic lab=_256__RESET_B}
N 3330 640 3370 640 {lab=_256__Q}
C {lab_pin.sym} 3370 640 0 1 {name=l380 sig_type=std_logic lab=_256__Q}
C {sg13cmos5l_buf_1.sym} 3810 640 0 0 {name=Xfanout80 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 640 3730 640 {lab=_255__A}
C {lab_pin.sym} 3730 640 0 0 {name=l383 sig_type=std_logic lab=_255__A}
N 3850 640 3890 640 {lab=_252__A}
C {lab_pin.sym} 3890 640 0 1 {name=l385 sig_type=std_logic lab=_252__A}
C {sg13cmos5l_nor2_1.sym} 4450 660 0 0 {name=X_239_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 640 4350 640 {lab=_251__B}
C {lab_pin.sym} 4350 640 0 0 {name=l388 sig_type=std_logic lab=_251__B}
N 4390 680 4350 680 {lab=_241__A}
C {lab_pin.sym} 4350 680 0 0 {name=l390 sig_type=std_logic lab=_241__A}
N 4510 660 4550 660 {lab=_240__C}
C {lab_pin.sym} 4550 660 0 1 {name=l392 sig_type=std_logic lab=_240__C}
C {sg13cmos5l_buf_1.sym} 5050 640 0 0 {name=Xoutput24 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 640 4970 640 {lab=_271__Q}
C {lab_pin.sym} 4970 640 0 0 {name=l395 sig_type=std_logic lab=_271__Q}
N 5090 640 5130 640 {lab=q[28]}
C {lab_pin.sym} 5130 640 0 1 {name=l397 sig_type=std_logic lab=q[28]}
C {sg13cmos5l_buf_1.sym} 5670 640 0 0 {name=Xoutput46 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 640 5590 640 {lab=_153__Y}
C {lab_pin.sym} 5590 640 0 0 {name=l400 sig_type=std_logic lab=_153__Y}
N 5710 640 5750 640 {lab=q_bar[19]}
C {lab_pin.sym} 5750 640 0 1 {name=l402 sig_type=std_logic lab=q_bar[19]}
C {sg13cmos5l_buf_1.sym} 6290 640 0 0 {name=Xoutput13 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 640 6210 640 {lab=_261__Q}
C {lab_pin.sym} 6210 640 0 0 {name=l405 sig_type=std_logic lab=_261__Q}
N 6330 640 6370 640 {lab=q[18]}
C {lab_pin.sym} 6370 640 0 1 {name=l407 sig_type=std_logic lab=q[18]}
C {sg13cmos5l_buf_1.sym} 6910 640 0 0 {name=Xoutput35 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 640 6830 640 {lab=_284__Q}
C {lab_pin.sym} 6830 640 0 0 {name=l410 sig_type=std_logic lab=_284__Q}
N 6950 640 6990 640 {lab=q[9]}
C {lab_pin.sym} 6990 640 0 1 {name=l412 sig_type=std_logic lab=q[9]}
C {sg13cmos5l_buf_1.sym} 7530 640 0 0 {name=Xoutput57 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 640 7450 640 {lab=_143__Y}
C {lab_pin.sym} 7450 640 0 0 {name=l415 sig_type=std_logic lab=_143__Y}
N 7570 640 7610 640 {lab=q_bar[29]}
C {lab_pin.sym} 7610 640 0 1 {name=l417 sig_type=std_logic lab=q_bar[29]}
C {sg13cmos5l_dlygate4sd3_1.sym} 710 800 0 0 {name=Xhold131 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 800 630 800 {lab=_280__Q}
C {lab_pin.sym} 630 800 0 0 {name=l420 sig_type=std_logic lab=_280__Q}
N 750 800 790 800 {lab=_233__B}
C {lab_pin.sym} 790 800 0 1 {name=l422 sig_type=std_logic lab=_233__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 1330 800 0 0 {name=Xhold142 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 800 1250 800 {lab=_231__Y}
C {lab_pin.sym} 1250 800 0 0 {name=l425 sig_type=std_logic lab=_231__Y}
N 1370 800 1410 800 {lab=_279__D}
C {lab_pin.sym} 1410 800 0 1 {name=l427 sig_type=std_logic lab=_279__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 1950 800 0 0 {name=Xhold120 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 800 1870 800 {lab=_281__Q}
C {lab_pin.sym} 1870 800 0 0 {name=l430 sig_type=std_logic lab=_281__Q}
N 1990 800 2030 800 {lab=_236__B}
C {lab_pin.sym} 2030 800 0 1 {name=l432 sig_type=std_logic lab=_236__B}
C {sg13cmos5l_dfrbpq_1.sym} 2620 820 0 0 {name=X_272_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 800 2490 800 {lab=clk}
C {lab_pin.sym} 2490 800 0 0 {name=l435 sig_type=std_logic lab=clk}
N 2530 820 2490 820 {lab=_272__D}
C {lab_pin.sym} 2490 820 0 0 {name=l437 sig_type=std_logic lab=_272__D}
N 2530 840 2490 840 {lab=_272__84_L_HI}
C {lab_pin.sym} 2490 840 0 0 {name=l439 sig_type=std_logic lab=_272__84_L_HI}
N 2710 800 2750 800 {lab=_272__Q}
C {lab_pin.sym} 2750 800 0 1 {name=l441 sig_type=std_logic lab=_272__Q}
C {sg13cmos5l_dlygate4sd3_1.sym} 3190 800 0 0 {name=Xhold153 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 800 3110 800 {lab=_285__Q}
C {lab_pin.sym} 3110 800 0 0 {name=l444 sig_type=std_logic lab=_285__Q}
N 3230 800 3270 800 {lab=_250__A}
C {lab_pin.sym} 3270 800 0 1 {name=l446 sig_type=std_logic lab=_250__A}
C {sg13cmos5l_nor3_1.sym} 3830 840 0 0 {name=X_186_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 800 3730 800 {lab=_195__A}
C {lab_pin.sym} 3730 800 0 0 {name=l449 sig_type=std_logic lab=_195__A}
N 3770 840 3730 840 {lab=_186__B}
C {lab_pin.sym} 3730 840 0 0 {name=l451 sig_type=std_logic lab=_186__B}
N 3770 880 3730 880 {lab=_186__C}
C {lab_pin.sym} 3730 880 0 0 {name=l453 sig_type=std_logic lab=_186__C}
N 3890 840 3930 840 {lab=_186__Y}
C {lab_pin.sym} 3930 840 0 1 {name=l455 sig_type=std_logic lab=_186__Y}
C {sg13cmos5l_buf_1.sym} 4430 800 0 0 {name=Xfanout70 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 800 4350 800 {lab=_247__B_N}
C {lab_pin.sym} 4350 800 0 0 {name=l458 sig_type=std_logic lab=_247__B_N}
N 4470 800 4510 800 {lab=_245__A}
C {lab_pin.sym} 4510 800 0 1 {name=l460 sig_type=std_logic lab=_245__A}
C {sg13cmos5l_nor3_1.sym} 5070 840 0 0 {name=X_255_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 800 4970 800 {lab=_255__A}
C {lab_pin.sym} 4970 800 0 0 {name=l463 sig_type=std_logic lab=_255__A}
N 5010 840 4970 840 {lab=_255__B}
C {lab_pin.sym} 4970 840 0 0 {name=l465 sig_type=std_logic lab=_255__B}
N 5010 880 4970 880 {lab=_255__C}
C {lab_pin.sym} 4970 880 0 0 {name=l467 sig_type=std_logic lab=_255__C}
N 5130 840 5170 840 {lab=_255__Y}
C {lab_pin.sym} 5170 840 0 1 {name=l469 sig_type=std_logic lab=_255__Y}
C {sg13cmos5l_buf_1.sym} 5670 800 0 0 {name=Xfanout81 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 800 5590 800 {lab=_195__A}
C {lab_pin.sym} 5590 800 0 0 {name=l472 sig_type=std_logic lab=_195__A}
N 5710 800 5750 800 {lab=_213__A}
C {lab_pin.sym} 5750 800 0 1 {name=l474 sig_type=std_logic lab=_213__A}
C {sg13cmos5l_nor2b_1.sym} 6310 820 0 0 {name=X_238_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 800 6210 800 {lab=_281__Q}
C {lab_pin.sym} 6210 800 0 0 {name=l477 sig_type=std_logic lab=_281__Q}
N 6250 840 6210 840 {lab=_251__B}
C {lab_pin.sym} 6210 840 0 0 {name=l479 sig_type=std_logic lab=_251__B}
N 6370 820 6410 820 {lab=_240__B}
C {lab_pin.sym} 6410 820 0 1 {name=l481 sig_type=std_logic lab=_240__B}
C {sg13cmos5l_nor2b_1.sym} 6930 820 0 0 {name=X_169_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 800 6830 800 {lab=_169__A}
C {lab_pin.sym} 6830 800 0 0 {name=l484 sig_type=std_logic lab=_169__A}
N 6870 840 6830 840 {lab=_176__A}
C {lab_pin.sym} 6830 840 0 0 {name=l486 sig_type=std_logic lab=_176__A}
N 6990 820 7030 820 {lab=_171__B}
C {lab_pin.sym} 7030 820 0 1 {name=l488 sig_type=std_logic lab=_171__B}
C {sg13cmos5l_buf_1.sym} 7530 800 0 0 {name=Xoutput14 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 800 7450 800 {lab=_262__Q}
C {lab_pin.sym} 7450 800 0 0 {name=l491 sig_type=std_logic lab=_262__Q}
N 7570 800 7610 800 {lab=q[19]}
C {lab_pin.sym} 7610 800 0 1 {name=l493 sig_type=std_logic lab=q[19]}
C {sg13cmos5l_buf_1.sym} 710 960 0 0 {name=Xoutput47 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 960 630 960 {lab=_139__Y}
C {lab_pin.sym} 630 960 0 0 {name=l496 sig_type=std_logic lab=_139__Y}
N 750 960 790 960 {lab=q_bar[1]}
C {lab_pin.sym} 790 960 0 1 {name=l498 sig_type=std_logic lab=q_bar[1]}
C {sg13cmos5l_buf_1.sym} 1330 960 0 0 {name=Xoutput25 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 960 1250 960 {lab=_272__Q}
C {lab_pin.sym} 1250 960 0 0 {name=l501 sig_type=std_logic lab=_272__Q}
N 1370 960 1410 960 {lab=q[29]}
C {lab_pin.sym} 1410 960 0 1 {name=l503 sig_type=std_logic lab=q[29]}
C {sg13cmos5l_buf_1.sym} 1950 960 0 0 {name=Xoutput58 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 960 1870 960 {lab=_138__Y}
C {lab_pin.sym} 1870 960 0 0 {name=l506 sig_type=std_logic lab=_138__Y}
N 1990 960 2030 960 {lab=q_bar[2]}
C {lab_pin.sym} 2030 960 0 1 {name=l508 sig_type=std_logic lab=q_bar[2]}
C {sg13cmos5l_buf_1.sym} 2570 960 0 0 {name=Xoutput36 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 960 2490 960 {lab=_140__Y}
C {lab_pin.sym} 2490 960 0 0 {name=l511 sig_type=std_logic lab=_140__Y}
N 2610 960 2650 960 {lab=q_bar[0]}
C {lab_pin.sym} 2650 960 0 1 {name=l513 sig_type=std_logic lab=q_bar[0]}
C {sg13cmos5l_dlygate4sd3_1.sym} 3190 960 0 0 {name=Xhold132 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 960 3110 960 {lab=_234__Y}
C {lab_pin.sym} 3110 960 0 0 {name=l516 sig_type=std_logic lab=_234__Y}
N 3230 960 3270 960 {lab=_280__D}
C {lab_pin.sym} 3270 960 0 1 {name=l518 sig_type=std_logic lab=_280__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 3810 960 0 0 {name=Xhold121 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 960 3730 960 {lab=_237__Y}
C {lab_pin.sym} 3730 960 0 0 {name=l521 sig_type=std_logic lab=_237__Y}
N 3850 960 3890 960 {lab=_281__D}
C {lab_pin.sym} 3890 960 0 1 {name=l523 sig_type=std_logic lab=_281__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 4430 960 0 0 {name=Xhold154 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 960 4350 960 {lab=_278__Q}
C {lab_pin.sym} 4350 960 0 0 {name=l526 sig_type=std_logic lab=_278__Q}
N 4470 960 4510 960 {lab=_227__B}
C {lab_pin.sym} 4510 960 0 1 {name=l528 sig_type=std_logic lab=_227__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 5050 960 0 0 {name=Xhold143 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 960 4970 960 {lab=_277__Q}
C {lab_pin.sym} 4970 960 0 0 {name=l531 sig_type=std_logic lab=_277__Q}
N 5090 960 5130 960 {lab=_226__A}
C {lab_pin.sym} 5130 960 0 1 {name=l533 sig_type=std_logic lab=_226__A}
C {sg13cmos5l_dfrbpq_1.sym} 5720 980 0 0 {name=X_271_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 960 5590 960 {lab=clk}
C {lab_pin.sym} 5590 960 0 0 {name=l536 sig_type=std_logic lab=clk}
N 5630 980 5590 980 {lab=_271__D}
C {lab_pin.sym} 5590 980 0 0 {name=l538 sig_type=std_logic lab=_271__D}
N 5630 1000 5590 1000 {lab=_271__86_L_HI}
C {lab_pin.sym} 5590 1000 0 0 {name=l540 sig_type=std_logic lab=_271__86_L_HI}
N 5810 960 5850 960 {lab=_271__Q}
C {lab_pin.sym} 5850 960 0 1 {name=l542 sig_type=std_logic lab=_271__Q}
C {sg13cmos5l_nor2_1.sym} 6310 980 0 0 {name=X_185_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 960 6210 960 {lab=_191__A}
C {lab_pin.sym} 6210 960 0 0 {name=l545 sig_type=std_logic lab=_191__A}
N 6250 1000 6210 1000 {lab=_187__A}
C {lab_pin.sym} 6210 1000 0 0 {name=l547 sig_type=std_logic lab=_187__A}
N 6370 980 6410 980 {lab=_186__C}
C {lab_pin.sym} 6410 980 0 1 {name=l549 sig_type=std_logic lab=_186__C}
C {sg13cmos5l_buf_1.sym} 6910 960 0 0 {name=Xfanout71 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 960 6830 960 {lab=_247__B_N}
C {lab_pin.sym} 6830 960 0 0 {name=l552 sig_type=std_logic lab=_247__B_N}
N 6950 960 6990 960 {lab=_251__B}
C {lab_pin.sym} 6990 960 0 1 {name=l554 sig_type=std_logic lab=_251__B}
C {sg13cmos5l_nor2_1.sym} 7550 980 0 0 {name=X_254_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 960 7450 960 {lab=_287__Q}
C {lab_pin.sym} 7450 960 0 0 {name=l557 sig_type=std_logic lab=_287__Q}
N 7490 1000 7450 1000 {lab=_254__B}
C {lab_pin.sym} 7450 1000 0 0 {name=l559 sig_type=std_logic lab=_254__B}
N 7610 980 7650 980 {lab=_255__C}
C {lab_pin.sym} 7650 980 0 1 {name=l561 sig_type=std_logic lab=_255__C}
C {sg13cmos5l_buf_1.sym} 710 1120 0 0 {name=Xfanout82 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 1120 630 1120 {lab=_255__A}
C {lab_pin.sym} 630 1120 0 0 {name=l564 sig_type=std_logic lab=_255__A}
N 750 1120 790 1120 {lab=_195__A}
C {lab_pin.sym} 790 1120 0 1 {name=l566 sig_type=std_logic lab=_195__A}
C {sg13cmos5l_tiehi.sym} 1290 1120 0 0 {name=X_261__106 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 1120 1250 1120 {lab=_261__RESET_B}
C {lab_pin.sym} 1250 1120 0 0 {name=l569 sig_type=std_logic lab=_261__RESET_B}
C {sg13cmos5l_nor3_1.sym} 1970 1160 0 0 {name=X_237_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 1120 1870 1120 {lab=_243__A}
C {lab_pin.sym} 1870 1120 0 0 {name=l572 sig_type=std_logic lab=_243__A}
N 1910 1160 1870 1160 {lab=_237__B}
C {lab_pin.sym} 1870 1160 0 0 {name=l574 sig_type=std_logic lab=_237__B}
N 1910 1200 1870 1200 {lab=_237__C}
C {lab_pin.sym} 1870 1200 0 0 {name=l576 sig_type=std_logic lab=_237__C}
N 2030 1160 2070 1160 {lab=_237__Y}
C {lab_pin.sym} 2070 1160 0 1 {name=l578 sig_type=std_logic lab=_237__Y}
C {sg13cmos5l_nor3_1.sym} 2590 1160 0 0 {name=X_168_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 1120 2490 1120 {lab=_252__A}
C {lab_pin.sym} 2490 1120 0 0 {name=l581 sig_type=std_logic lab=_252__A}
N 2530 1160 2490 1160 {lab=_168__B}
C {lab_pin.sym} 2490 1160 0 0 {name=l583 sig_type=std_logic lab=_168__B}
N 2530 1200 2490 1200 {lab=_168__C}
C {lab_pin.sym} 2490 1200 0 0 {name=l585 sig_type=std_logic lab=_168__C}
N 2650 1160 2690 1160 {lab=_258__D}
C {lab_pin.sym} 2690 1160 0 1 {name=l587 sig_type=std_logic lab=_258__D}
C {sg13cmos5l_buf_1.sym} 3190 1120 0 0 {name=Xoutput48 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 1120 3110 1120 {lab=_152__Y}
C {lab_pin.sym} 3110 1120 0 0 {name=l590 sig_type=std_logic lab=_152__Y}
N 3230 1120 3270 1120 {lab=q_bar[20]}
C {lab_pin.sym} 3270 1120 0 1 {name=l592 sig_type=std_logic lab=q_bar[20]}
C {sg13cmos5l_buf_1.sym} 3810 1120 0 0 {name=Xoutput37 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 1120 3730 1120 {lab=_130__Y}
C {lab_pin.sym} 3730 1120 0 0 {name=l595 sig_type=std_logic lab=_130__Y}
N 3850 1120 3890 1120 {lab=q_bar[10]}
C {lab_pin.sym} 3890 1120 0 1 {name=l597 sig_type=std_logic lab=q_bar[10]}
C {sg13cmos5l_buf_1.sym} 4430 1120 0 0 {name=Xoutput15 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 1120 4350 1120 {lab=_276__Q}
C {lab_pin.sym} 4350 1120 0 0 {name=l600 sig_type=std_logic lab=_276__Q}
N 4470 1120 4510 1120 {lab=q[1]}
C {lab_pin.sym} 4510 1120 0 1 {name=l602 sig_type=std_logic lab=q[1]}
C {sg13cmos5l_buf_1.sym} 5050 1120 0 0 {name=Xoutput26 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 1120 4970 1120 {lab=_277__Q}
C {lab_pin.sym} 4970 1120 0 0 {name=l605 sig_type=std_logic lab=_277__Q}
N 5090 1120 5130 1120 {lab=q[2]}
C {lab_pin.sym} 5130 1120 0 1 {name=l607 sig_type=std_logic lab=q[2]}
C {sg13cmos5l_buf_1.sym} 5670 1120 0 0 {name=Xoutput59 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 1120 5590 1120 {lab=_142__Y}
C {lab_pin.sym} 5590 1120 0 0 {name=l610 sig_type=std_logic lab=_142__Y}
N 5710 1120 5750 1120 {lab=q_bar[30]}
C {lab_pin.sym} 5750 1120 0 1 {name=l612 sig_type=std_logic lab=q_bar[30]}
C {sg13cmos5l_dlygate4sd3_1.sym} 6290 1120 0 0 {name=Xhold122 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 1120 6210 1120 {lab=_257__Q}
C {lab_pin.sym} 6210 1120 0 0 {name=l615 sig_type=std_logic lab=_257__Q}
N 6330 1120 6370 1120 {lab=_166__A}
C {lab_pin.sym} 6370 1120 0 1 {name=l617 sig_type=std_logic lab=_166__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 6910 1120 0 0 {name=Xhold133 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 1120 6830 1120 {lab=_273__Q}
C {lab_pin.sym} 6830 1120 0 0 {name=l620 sig_type=std_logic lab=_273__Q}
N 6950 1120 6990 1120 {lab=_212__B}
C {lab_pin.sym} 6990 1120 0 1 {name=l622 sig_type=std_logic lab=_212__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 7530 1120 0 0 {name=Xhold144 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 1120 7450 1120 {lab=_225__Y}
C {lab_pin.sym} 7450 1120 0 0 {name=l625 sig_type=std_logic lab=_225__Y}
N 7570 1120 7610 1120 {lab=_277__D}
C {lab_pin.sym} 7610 1120 0 1 {name=l627 sig_type=std_logic lab=_277__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 710 1280 0 0 {name=Xhold155 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 1280 630 1280 {lab=_267__Q}
C {lab_pin.sym} 630 1280 0 0 {name=l630 sig_type=std_logic lab=_267__Q}
N 750 1280 790 1280 {lab=_196__A}
C {lab_pin.sym} 790 1280 0 1 {name=l632 sig_type=std_logic lab=_196__A}
C {sg13cmos5l_dfrbpq_1.sym} 1380 1300 0 0 {name=X_270_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 1280 1250 1280 {lab=clk}
C {lab_pin.sym} 1250 1280 0 0 {name=l635 sig_type=std_logic lab=clk}
N 1290 1300 1250 1300 {lab=_270__D}
C {lab_pin.sym} 1250 1300 0 0 {name=l637 sig_type=std_logic lab=_270__D}
N 1290 1320 1250 1320 {lab=_270__88_L_HI}
C {lab_pin.sym} 1250 1320 0 0 {name=l639 sig_type=std_logic lab=_270__88_L_HI}
N 1470 1280 1510 1280 {lab=_270__Q}
C {lab_pin.sym} 1510 1280 0 1 {name=l641 sig_type=std_logic lab=_270__Q}
C {sg13cmos5l_nor2b_1.sym} 1970 1300 0 0 {name=X_184_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 1280 1870 1280 {lab=_263__Q}
C {lab_pin.sym} 1870 1280 0 0 {name=l644 sig_type=std_logic lab=_263__Q}
N 1910 1320 1870 1320 {lab=_176__A}
C {lab_pin.sym} 1870 1320 0 0 {name=l646 sig_type=std_logic lab=_176__A}
N 2030 1300 2070 1300 {lab=_186__B}
C {lab_pin.sym} 2070 1300 0 1 {name=l648 sig_type=std_logic lab=_186__B}
C {sg13cmos5l_nor2b_1.sym} 2590 1300 0 0 {name=X_253_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 1280 2490 1280 {lab=_253__A}
C {lab_pin.sym} 2490 1280 0 0 {name=l651 sig_type=std_logic lab=_253__A}
N 2530 1320 2490 1320 {lab=_254__B}
C {lab_pin.sym} 2490 1320 0 0 {name=l653 sig_type=std_logic lab=_254__B}
N 2650 1300 2690 1300 {lab=_255__B}
C {lab_pin.sym} 2690 1300 0 1 {name=l655 sig_type=std_logic lab=_255__B}
C {sg13cmos5l_buf_1.sym} 3190 1280 0 0 {name=Xfanout72 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 1280 3110 1280 {lab=_247__B_N}
C {lab_pin.sym} 3110 1280 0 0 {name=l658 sig_type=std_logic lab=_247__B_N}
N 3230 1280 3270 1280 {lab=_254__B}
C {lab_pin.sym} 3270 1280 0 1 {name=l660 sig_type=std_logic lab=_254__B}
C {sg13cmos5l_buf_1.sym} 3810 1280 0 0 {name=Xfanout83 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 1280 3730 1280 {lab=input1_X}
C {lab_pin.sym} 3730 1280 0 0 {name=l663 sig_type=std_logic lab=input1_X}
N 3850 1280 3890 1280 {lab=_255__A}
C {lab_pin.sym} 3890 1280 0 1 {name=l665 sig_type=std_logic lab=_255__A}
C {sg13cmos5l_nor2_1.sym} 4450 1300 0 0 {name=X_236_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 1280 4350 1280 {lab=_245__A}
C {lab_pin.sym} 4350 1280 0 0 {name=l668 sig_type=std_logic lab=_245__A}
N 4390 1320 4350 1320 {lab=_236__B}
C {lab_pin.sym} 4350 1320 0 0 {name=l670 sig_type=std_logic lab=_236__B}
N 4510 1300 4550 1300 {lab=_237__C}
C {lab_pin.sym} 4550 1300 0 1 {name=l672 sig_type=std_logic lab=_237__C}
C {sg13cmos5l_nor2_1.sym} 5070 1300 0 0 {name=X_167_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 1280 4970 1280 {lab=_254__B}
C {lab_pin.sym} 4970 1280 0 0 {name=l675 sig_type=std_logic lab=_254__B}
N 5010 1320 4970 1320 {lab=_169__A}
C {lab_pin.sym} 4970 1320 0 0 {name=l677 sig_type=std_logic lab=_169__A}
N 5130 1300 5170 1300 {lab=_168__C}
C {lab_pin.sym} 5170 1300 0 1 {name=l679 sig_type=std_logic lab=_168__C}
C {sg13cmos5l_nor3_1.sym} 5690 1320 0 0 {name=X_219_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 1280 5590 1280 {lab=_243__A}
C {lab_pin.sym} 5590 1280 0 0 {name=l682 sig_type=std_logic lab=_243__A}
N 5630 1320 5590 1320 {lab=_219__B}
C {lab_pin.sym} 5590 1320 0 0 {name=l684 sig_type=std_logic lab=_219__B}
N 5630 1360 5590 1360 {lab=_219__C}
C {lab_pin.sym} 5590 1360 0 0 {name=l686 sig_type=std_logic lab=_219__C}
N 5750 1320 5790 1320 {lab=_275__D}
C {lab_pin.sym} 5790 1320 0 1 {name=l688 sig_type=std_logic lab=_275__D}
C {sg13cmos5l_buf_1.sym} 6290 1280 0 0 {name=Xoutput49 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 1280 6210 1280 {lab=_151__Y}
C {lab_pin.sym} 6210 1280 0 0 {name=l691 sig_type=std_logic lab=_151__Y}
N 6330 1280 6370 1280 {lab=q_bar[21]}
C {lab_pin.sym} 6370 1280 0 1 {name=l693 sig_type=std_logic lab=q_bar[21]}
C {sg13cmos5l_buf_1.sym} 6910 1280 0 0 {name=Xoutput16 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 1280 6830 1280 {lab=_263__Q}
C {lab_pin.sym} 6830 1280 0 0 {name=l696 sig_type=std_logic lab=_263__Q}
N 6950 1280 6990 1280 {lab=q[20]}
C {lab_pin.sym} 6990 1280 0 1 {name=l698 sig_type=std_logic lab=q[20]}
C {sg13cmos5l_buf_1.sym} 7530 1280 0 0 {name=Xoutput38 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 1280 7450 1280 {lab=_129__Y}
C {lab_pin.sym} 7450 1280 0 0 {name=l701 sig_type=std_logic lab=_129__Y}
N 7570 1280 7610 1280 {lab=q_bar[11]}
C {lab_pin.sym} 7610 1280 0 1 {name=l703 sig_type=std_logic lab=q_bar[11]}
C {sg13cmos5l_buf_1.sym} 710 1440 0 0 {name=Xoutput27 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 1440 630 1440 {lab=_273__Q}
C {lab_pin.sym} 630 1440 0 0 {name=l706 sig_type=std_logic lab=_273__Q}
N 750 1440 790 1440 {lab=q[30]}
C {lab_pin.sym} 790 1440 0 1 {name=l708 sig_type=std_logic lab=q[30]}
C {sg13cmos5l_dlygate4sd3_1.sym} 1330 1440 0 0 {name=Xhold123 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 1440 1250 1440 {lab=_165__Y}
C {lab_pin.sym} 1250 1440 0 0 {name=l711 sig_type=std_logic lab=_165__Y}
N 1370 1440 1410 1440 {lab=_257__D}
C {lab_pin.sym} 1410 1440 0 1 {name=l713 sig_type=std_logic lab=_257__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 1950 1440 0 0 {name=Xhold134 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 1440 1870 1440 {lab=_213__Y}
C {lab_pin.sym} 1870 1440 0 0 {name=l716 sig_type=std_logic lab=_213__Y}
N 1990 1440 2030 1440 {lab=_273__D}
C {lab_pin.sym} 2030 1440 0 1 {name=l718 sig_type=std_logic lab=_273__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 2570 1440 0 0 {name=Xhold145 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 1440 2490 1440 {lab=_284__Q}
C {lab_pin.sym} 2490 1440 0 0 {name=l721 sig_type=std_logic lab=_284__Q}
N 2610 1440 2650 1440 {lab=_247__A}
C {lab_pin.sym} 2650 1440 0 1 {name=l723 sig_type=std_logic lab=_247__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 3190 1440 0 0 {name=Xhold156 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 1440 3110 1440 {lab=_195__Y}
C {lab_pin.sym} 3110 1440 0 0 {name=l726 sig_type=std_logic lab=_195__Y}
N 3230 1440 3270 1440 {lab=_267__D}
C {lab_pin.sym} 3270 1440 0 1 {name=l728 sig_type=std_logic lab=_267__D}
C {sg13cmos5l_nor3_1.sym} 3830 1480 0 0 {name=X_183_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 1440 3730 1440 {lab=_213__A}
C {lab_pin.sym} 3730 1440 0 0 {name=l731 sig_type=std_logic lab=_213__A}
N 3770 1480 3730 1480 {lab=_183__B}
C {lab_pin.sym} 3730 1480 0 0 {name=l733 sig_type=std_logic lab=_183__B}
N 3770 1520 3730 1520 {lab=_183__C}
C {lab_pin.sym} 3730 1520 0 0 {name=l735 sig_type=std_logic lab=_183__C}
N 3890 1480 3930 1480 {lab=_263__D}
C {lab_pin.sym} 3930 1480 0 1 {name=l737 sig_type=std_logic lab=_263__D}
C {sg13cmos5l_nor3_1.sym} 4450 1480 0 0 {name=X_252_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 1440 4350 1440 {lab=_252__A}
C {lab_pin.sym} 4350 1440 0 0 {name=l740 sig_type=std_logic lab=_252__A}
N 4390 1480 4350 1480 {lab=_252__B}
C {lab_pin.sym} 4350 1480 0 0 {name=l742 sig_type=std_logic lab=_252__B}
N 4390 1520 4350 1520 {lab=_252__C}
C {lab_pin.sym} 4350 1520 0 0 {name=l744 sig_type=std_logic lab=_252__C}
N 4510 1480 4550 1480 {lab=_286__D}
C {lab_pin.sym} 4550 1480 0 1 {name=l746 sig_type=std_logic lab=_286__D}
C {sg13cmos5l_buf_1.sym} 5050 1440 0 0 {name=Xfanout73 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 1440 4970 1440 {lab=input3_X}
C {lab_pin.sym} 4970 1440 0 0 {name=l749 sig_type=std_logic lab=input3_X}
N 5090 1440 5130 1440 {lab=_247__B_N}
C {lab_pin.sym} 5130 1440 0 1 {name=l751 sig_type=std_logic lab=_247__B_N}
C {sg13cmos5l_nor2b_1.sym} 5690 1460 0 0 {name=X_235_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 1440 5590 1440 {lab=_280__Q}
C {lab_pin.sym} 5590 1440 0 0 {name=l754 sig_type=std_logic lab=_280__Q}
N 5630 1480 5590 1480 {lab=_245__A}
C {lab_pin.sym} 5590 1480 0 0 {name=l756 sig_type=std_logic lab=_245__A}
N 5750 1460 5790 1460 {lab=_237__B}
C {lab_pin.sym} 5790 1460 0 1 {name=l758 sig_type=std_logic lab=_237__B}
C {sg13cmos5l_nor2b_1.sym} 6310 1460 0 0 {name=X_166_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 1440 6210 1440 {lab=_166__A}
C {lab_pin.sym} 6210 1440 0 0 {name=l761 sig_type=std_logic lab=_166__A}
N 6250 1480 6210 1480 {lab=_254__B}
C {lab_pin.sym} 6210 1480 0 0 {name=l763 sig_type=std_logic lab=_254__B}
N 6370 1460 6410 1460 {lab=_168__B}
C {lab_pin.sym} 6410 1460 0 1 {name=l765 sig_type=std_logic lab=_168__B}
C {sg13cmos5l_inv_1.sym} 6910 1440 0 0 {name=X_149_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 1440 6830 1440 {lab=_266__Q}
C {lab_pin.sym} 6830 1440 0 0 {name=l768 sig_type=std_logic lab=_266__Q}
N 6950 1440 6990 1440 {lab=_149__Y}
C {lab_pin.sym} 6990 1440 0 1 {name=l770 sig_type=std_logic lab=_149__Y}
C {sg13cmos5l_nor2_1.sym} 7550 1460 0 0 {name=X_218_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 1440 7450 1440 {lab=_233__A}
C {lab_pin.sym} 7450 1440 0 0 {name=l773 sig_type=std_logic lab=_233__A}
N 7490 1480 7450 1480 {lab=_220__A}
C {lab_pin.sym} 7450 1480 0 0 {name=l775 sig_type=std_logic lab=_220__A}
N 7610 1460 7650 1460 {lab=_219__C}
C {lab_pin.sym} 7650 1460 0 1 {name=l777 sig_type=std_logic lab=_219__C}
C {sg13cmos5l_buf_1.sym} 710 1600 0 0 {name=Xoutput17 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 1600 630 1600 {lab=_264__Q}
C {lab_pin.sym} 630 1600 0 0 {name=l780 sig_type=std_logic lab=_264__Q}
N 750 1600 790 1600 {lab=q[21]}
C {lab_pin.sym} 790 1600 0 1 {name=l782 sig_type=std_logic lab=q[21]}
C {sg13cmos5l_buf_1.sym} 1330 1600 0 0 {name=Xoutput39 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 1600 1250 1600 {lab=_128__Y}
C {lab_pin.sym} 1250 1600 0 0 {name=l785 sig_type=std_logic lab=_128__Y}
N 1370 1600 1410 1600 {lab=q_bar[12]}
C {lab_pin.sym} 1410 1600 0 1 {name=l787 sig_type=std_logic lab=q_bar[12]}
C {sg13cmos5l_buf_1.sym} 1950 1600 0 0 {name=Xoutput28 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 1600 1870 1600 {lab=_274__Q}
C {lab_pin.sym} 1870 1600 0 0 {name=l790 sig_type=std_logic lab=_274__Q}
N 1990 1600 2030 1600 {lab=q[31]}
C {lab_pin.sym} 2030 1600 0 1 {name=l792 sig_type=std_logic lab=q[31]}
C {sg13cmos5l_dlygate4sd3_1.sym} 2570 1600 0 0 {name=Xhold146 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 1600 2490 1600 {lab=_260__Q}
C {lab_pin.sym} 2490 1600 0 0 {name=l795 sig_type=std_logic lab=_260__Q}
N 2610 1600 2650 1600 {lab=_173__B}
C {lab_pin.sym} 2650 1600 0 1 {name=l797 sig_type=std_logic lab=_173__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 3190 1600 0 0 {name=Xhold124 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 1600 3110 1600 {lab=_264__Q}
C {lab_pin.sym} 3110 1600 0 0 {name=l800 sig_type=std_logic lab=_264__Q}
N 3230 1600 3270 1600 {lab=_187__A}
C {lab_pin.sym} 3270 1600 0 1 {name=l802 sig_type=std_logic lab=_187__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 3810 1600 0 0 {name=Xhold135 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 1600 3730 1600 {lab=_270__Q}
C {lab_pin.sym} 3730 1600 0 0 {name=l805 sig_type=std_logic lab=_270__Q}
N 3850 1600 3890 1600 {lab=_205__A}
C {lab_pin.sym} 3890 1600 0 1 {name=l807 sig_type=std_logic lab=_205__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 4430 1600 0 0 {name=Xhold157 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 1600 4350 1600 {lab=_271__Q}
C {lab_pin.sym} 4350 1600 0 0 {name=l810 sig_type=std_logic lab=_271__Q}
N 4470 1600 4510 1600 {lab=_206__B}
C {lab_pin.sym} 4510 1600 0 1 {name=l812 sig_type=std_logic lab=_206__B}
C {sg13cmos5l_nor2_1.sym} 5070 1620 0 0 {name=X_182_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 1600 4970 1600 {lab=_200__A}
C {lab_pin.sym} 4970 1600 0 0 {name=l815 sig_type=std_logic lab=_200__A}
N 5010 1640 4970 1640 {lab=_182__B}
C {lab_pin.sym} 4970 1640 0 0 {name=l817 sig_type=std_logic lab=_182__B}
N 5130 1620 5170 1620 {lab=_183__C}
C {lab_pin.sym} 5170 1620 0 1 {name=l819 sig_type=std_logic lab=_183__C}
C {sg13cmos5l_buf_1.sym} 5670 1600 0 0 {name=Xfanout74 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 1600 5590 1600 {lab=_206__A}
C {lab_pin.sym} 5590 1600 0 0 {name=l822 sig_type=std_logic lab=_206__A}
N 5710 1600 5750 1600 {lab=_176__A}
C {lab_pin.sym} 5750 1600 0 1 {name=l824 sig_type=std_logic lab=_176__A}
C {sg13cmos5l_nor2_1.sym} 6310 1620 0 0 {name=X_251_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 1600 6210 1600 {lab=_253__A}
C {lab_pin.sym} 6210 1600 0 0 {name=l827 sig_type=std_logic lab=_253__A}
N 6250 1640 6210 1640 {lab=_251__B}
C {lab_pin.sym} 6210 1640 0 0 {name=l829 sig_type=std_logic lab=_251__B}
N 6370 1620 6410 1620 {lab=_252__C}
C {lab_pin.sym} 6410 1620 0 1 {name=l831 sig_type=std_logic lab=_252__C}
C {sg13cmos5l_nor3_1.sym} 6930 1640 0 0 {name=X_165_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 1600 6830 1600 {lab=_252__A}
C {lab_pin.sym} 6830 1600 0 0 {name=l834 sig_type=std_logic lab=_252__A}
N 6870 1640 6830 1640 {lab=_165__B}
C {lab_pin.sym} 6830 1640 0 0 {name=l836 sig_type=std_logic lab=_165__B}
N 6870 1680 6830 1680 {lab=_165__C}
C {lab_pin.sym} 6830 1680 0 0 {name=l838 sig_type=std_logic lab=_165__C}
N 6990 1640 7030 1640 {lab=_165__Y}
C {lab_pin.sym} 7030 1640 0 1 {name=l840 sig_type=std_logic lab=_165__Y}
C {sg13cmos5l_nor3_1.sym} 7550 1640 0 0 {name=X_234_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 1600 7450 1600 {lab=_243__A}
C {lab_pin.sym} 7450 1600 0 0 {name=l843 sig_type=std_logic lab=_243__A}
N 7490 1640 7450 1640 {lab=_234__B}
C {lab_pin.sym} 7450 1640 0 0 {name=l845 sig_type=std_logic lab=_234__B}
N 7490 1680 7450 1680 {lab=_234__C}
C {lab_pin.sym} 7450 1680 0 0 {name=l847 sig_type=std_logic lab=_234__C}
N 7610 1640 7650 1640 {lab=_234__Y}
C {lab_pin.sym} 7650 1640 0 1 {name=l849 sig_type=std_logic lab=_234__Y}
C {sg13cmos5l_nor2b_1.sym} 730 1780 0 0 {name=X_217_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 1760 630 1760 {lab=_217__A}
C {lab_pin.sym} 630 1760 0 0 {name=l852 sig_type=std_logic lab=_217__A}
N 670 1800 630 1800 {lab=_233__A}
C {lab_pin.sym} 630 1800 0 0 {name=l854 sig_type=std_logic lab=_233__A}
N 790 1780 830 1780 {lab=_219__B}
C {lab_pin.sym} 830 1780 0 1 {name=l856 sig_type=std_logic lab=_219__B}
C {sg13cmos5l_inv_1.sym} 1330 1760 0 0 {name=X_148_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 1760 1250 1760 {lab=_267__Q}
C {lab_pin.sym} 1250 1760 0 0 {name=l859 sig_type=std_logic lab=_267__Q}
N 1370 1760 1410 1760 {lab=_148__Y}
C {lab_pin.sym} 1410 1760 0 1 {name=l861 sig_type=std_logic lab=_148__Y}
C {sg13cmos5l_buf_1.sym} 1950 1760 0 0 {name=Xoutput18 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 1760 1870 1760 {lab=_265__Q}
C {lab_pin.sym} 1870 1760 0 0 {name=l864 sig_type=std_logic lab=_265__Q}
N 1990 1760 2030 1760 {lab=q[22]}
C {lab_pin.sym} 2030 1760 0 1 {name=l866 sig_type=std_logic lab=q[22]}
C {sg13cmos5l_buf_1.sym} 2570 1760 0 0 {name=Xoutput29 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 1760 2490 1760 {lab=_278__Q}
C {lab_pin.sym} 2490 1760 0 0 {name=l869 sig_type=std_logic lab=_278__Q}
N 2610 1760 2650 1760 {lab=q[3]}
C {lab_pin.sym} 2650 1760 0 1 {name=l871 sig_type=std_logic lab=q[3]}
C {sg13cmos5l_tiehi.sym} 3150 1760 0 0 {name=X_257__114 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 1760 3110 1760 {lab=_257__RESET_B}
C {lab_pin.sym} 3110 1760 0 0 {name=l874 sig_type=std_logic lab=_257__RESET_B}
C {sg13cmos5l_dlygate4sd3_1.sym} 3810 1760 0 0 {name=Xhold125 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 1760 3730 1760 {lab=_186__Y}
C {lab_pin.sym} 3730 1760 0 0 {name=l877 sig_type=std_logic lab=_186__Y}
N 3850 1760 3890 1760 {lab=_264__D}
C {lab_pin.sym} 3890 1760 0 1 {name=l879 sig_type=std_logic lab=_264__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 4430 1760 0 0 {name=Xhold136 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 1760 4350 1760 {lab=_258__Q}
C {lab_pin.sym} 4350 1760 0 0 {name=l882 sig_type=std_logic lab=_258__Q}
N 4470 1760 4510 1760 {lab=_169__A}
C {lab_pin.sym} 4510 1760 0 1 {name=l884 sig_type=std_logic lab=_169__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 5050 1760 0 0 {name=Xhold147 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 1760 4970 1760 {lab=_174__Y}
C {lab_pin.sym} 4970 1760 0 0 {name=l887 sig_type=std_logic lab=_174__Y}
N 5090 1760 5130 1760 {lab=_260__D}
C {lab_pin.sym} 5130 1760 0 1 {name=l889 sig_type=std_logic lab=_260__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 5670 1760 0 0 {name=Xhold158 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 1760 5590 1760 {lab=_276__Q}
C {lab_pin.sym} 5590 1760 0 0 {name=l892 sig_type=std_logic lab=_276__Q}
N 5710 1760 5750 1760 {lab=_221__B}
C {lab_pin.sym} 5750 1760 0 1 {name=l894 sig_type=std_logic lab=_221__B}
C {sg13cmos5l_nor2b_1.sym} 6310 1780 0 0 {name=X_181_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 1760 6210 1760 {lab=_181__A}
C {lab_pin.sym} 6210 1760 0 0 {name=l897 sig_type=std_logic lab=_181__A}
N 6250 1800 6210 1800 {lab=_200__A}
C {lab_pin.sym} 6210 1800 0 0 {name=l899 sig_type=std_logic lab=_200__A}
N 6370 1780 6410 1780 {lab=_183__B}
C {lab_pin.sym} 6410 1780 0 1 {name=l901 sig_type=std_logic lab=_183__B}
C {sg13cmos5l_nor2b_1.sym} 6930 1780 0 0 {name=X_250_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 1760 6830 1760 {lab=_250__A}
C {lab_pin.sym} 6830 1760 0 0 {name=l904 sig_type=std_logic lab=_250__A}
N 6870 1800 6830 1800 {lab=_251__B}
C {lab_pin.sym} 6830 1800 0 0 {name=l906 sig_type=std_logic lab=_251__B}
N 6990 1780 7030 1780 {lab=_252__B}
C {lab_pin.sym} 7030 1780 0 1 {name=l908 sig_type=std_logic lab=_252__B}
C {sg13cmos5l_buf_1.sym} 7530 1760 0 0 {name=Xfanout75 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 1760 7450 1760 {lab=_206__A}
C {lab_pin.sym} 7450 1760 0 0 {name=l911 sig_type=std_logic lab=_206__A}
N 7570 1760 7610 1760 {lab=_191__A}
C {lab_pin.sym} 7610 1760 0 1 {name=l913 sig_type=std_logic lab=_191__A}
C {sg13cmos5l_nor2_1.sym} 730 1940 0 0 {name=X_164_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 1920 630 1920 {lab=_254__B}
C {lab_pin.sym} 630 1920 0 0 {name=l916 sig_type=std_logic lab=_254__B}
N 670 1960 630 1960 {lab=_166__A}
C {lab_pin.sym} 630 1960 0 0 {name=l918 sig_type=std_logic lab=_166__A}
N 790 1940 830 1940 {lab=_165__C}
C {lab_pin.sym} 830 1940 0 1 {name=l920 sig_type=std_logic lab=_165__C}
C {sg13cmos5l_tiehi.sym} 1290 1920 0 0 {name=X_279__89 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 1920 1250 1920 {lab=_279__89_L_HI}
C {lab_pin.sym} 1250 1920 0 0 {name=l923 sig_type=std_logic lab=_279__89_L_HI}
C {sg13cmos5l_nor2_1.sym} 1970 1940 0 0 {name=X_233_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 1920 1870 1920 {lab=_233__A}
C {lab_pin.sym} 1870 1920 0 0 {name=l926 sig_type=std_logic lab=_233__A}
N 1910 1960 1870 1960 {lab=_233__B}
C {lab_pin.sym} 1870 1960 0 0 {name=l928 sig_type=std_logic lab=_233__B}
N 2030 1940 2070 1940 {lab=_234__C}
C {lab_pin.sym} 2070 1940 0 1 {name=l930 sig_type=std_logic lab=_234__C}
C {sg13cmos5l_inv_1.sym} 2570 1920 0 0 {name=X_147_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 1920 2490 1920 {lab=_268__Q}
C {lab_pin.sym} 2490 1920 0 0 {name=l933 sig_type=std_logic lab=_268__Q}
N 2610 1920 2650 1920 {lab=_147__Y}
C {lab_pin.sym} 2650 1920 0 1 {name=l935 sig_type=std_logic lab=_147__Y}
C {sg13cmos5l_nor3_1.sym} 3210 1960 0 0 {name=X_216_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 1920 3110 1920 {lab=_255__A}
C {lab_pin.sym} 3110 1920 0 0 {name=l938 sig_type=std_logic lab=_255__A}
N 3150 1960 3110 1960 {lab=_216__B}
C {lab_pin.sym} 3110 1960 0 0 {name=l940 sig_type=std_logic lab=_216__B}
N 3150 2000 3110 2000 {lab=_216__C}
C {lab_pin.sym} 3110 2000 0 0 {name=l942 sig_type=std_logic lab=_216__C}
N 3270 1960 3310 1960 {lab=_216__Y}
C {lab_pin.sym} 3310 1960 0 1 {name=l944 sig_type=std_logic lab=_216__Y}
C {sg13cmos5l_buf_1.sym} 3810 1920 0 0 {name=Xoutput19 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 1920 3730 1920 {lab=_266__Q}
C {lab_pin.sym} 3730 1920 0 0 {name=l947 sig_type=std_logic lab=_266__Q}
N 3850 1920 3890 1920 {lab=q[23]}
C {lab_pin.sym} 3890 1920 0 1 {name=l949 sig_type=std_logic lab=q[23]}
C {sg13cmos5l_tiehi.sym} 4390 1920 0 0 {name=X_274__109 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 1920 4350 1920 {lab=_274__RESET_B}
C {lab_pin.sym} 4350 1920 0 0 {name=l952 sig_type=std_logic lab=_274__RESET_B}
C {sg13cmos5l_tiehi.sym} 5010 1920 0 0 {name=X_272__84 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 1920 4970 1920 {lab=_272__84_L_HI}
C {lab_pin.sym} 4970 1920 0 0 {name=l955 sig_type=std_logic lab=_272__84_L_HI}
C {sg13cmos5l_decap_4.sym} 5670 1940 0 0 {name=XFILLER_8_137 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
C {sg13cmos5l_dlygate4sd3_1.sym} 6290 1920 0 0 {name=Xhold126 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 1920 6210 1920 {lab=_261__Q}
C {lab_pin.sym} 6210 1920 0 0 {name=l959 sig_type=std_logic lab=_261__Q}
N 6330 1920 6370 1920 {lab=_178__A}
C {lab_pin.sym} 6370 1920 0 1 {name=l961 sig_type=std_logic lab=_178__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 6910 1920 0 0 {name=Xhold159 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 1920 6830 1920 {lab=_256__Q}
C {lab_pin.sym} 6830 1920 0 0 {name=l964 sig_type=std_logic lab=_256__Q}
N 6950 1920 6990 1920 {lab=_161__B}
C {lab_pin.sym} 6990 1920 0 1 {name=l966 sig_type=std_logic lab=_161__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 7530 1920 0 0 {name=Xhold148 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 1920 7450 1920 {lab=_275__Q}
C {lab_pin.sym} 7450 1920 0 0 {name=l969 sig_type=std_logic lab=_275__Q}
N 7570 1920 7610 1920 {lab=_220__A}
C {lab_pin.sym} 7610 1920 0 1 {name=l971 sig_type=std_logic lab=_220__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 710 2080 0 0 {name=Xhold137 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 2080 630 2080 {lab=_171__Y}
C {lab_pin.sym} 630 2080 0 0 {name=l974 sig_type=std_logic lab=_171__Y}
N 750 2080 790 2080 {lab=_259__D}
C {lab_pin.sym} 790 2080 0 1 {name=l976 sig_type=std_logic lab=_259__D}
C {sg13cmos5l_nor3_1.sym} 1350 2120 0 0 {name=X_180_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 2080 1250 2080 {lab=_213__A}
C {lab_pin.sym} 1250 2080 0 0 {name=l979 sig_type=std_logic lab=_213__A}
N 1290 2120 1250 2120 {lab=_180__B}
C {lab_pin.sym} 1250 2120 0 0 {name=l981 sig_type=std_logic lab=_180__B}
N 1290 2160 1250 2160 {lab=_180__C}
C {lab_pin.sym} 1250 2160 0 0 {name=l983 sig_type=std_logic lab=_180__C}
N 1410 2120 1450 2120 {lab=_262__D}
C {lab_pin.sym} 1450 2120 0 1 {name=l985 sig_type=std_logic lab=_262__D}
C {sg13cmos5l_buf_1.sym} 1950 2080 0 0 {name=Xfanout76 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 2080 1870 2080 {lab=_200__A}
C {lab_pin.sym} 1870 2080 0 0 {name=l988 sig_type=std_logic lab=_200__A}
N 1990 2080 2030 2080 {lab=_215__A}
C {lab_pin.sym} 2030 2080 0 1 {name=l990 sig_type=std_logic lab=_215__A}
C {sg13cmos5l_nor2b_1.sym} 2590 2100 0 0 {name=X_163_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 2080 2490 2080 {lab=_256__Q}
C {lab_pin.sym} 2490 2080 0 0 {name=l993 sig_type=std_logic lab=_256__Q}
N 2530 2120 2490 2120 {lab=_251__B}
C {lab_pin.sym} 2490 2120 0 0 {name=l995 sig_type=std_logic lab=_251__B}
N 2650 2100 2690 2100 {lab=_165__B}
C {lab_pin.sym} 2690 2100 0 1 {name=l997 sig_type=std_logic lab=_165__B}
C {sg13cmos5l_nor2b_1.sym} 3210 2100 0 0 {name=X_232_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 2080 3110 2080 {lab=_279__Q}
C {lab_pin.sym} 3110 2080 0 0 {name=l1000 sig_type=std_logic lab=_279__Q}
N 3150 2120 3110 2120 {lab=_233__A}
C {lab_pin.sym} 3110 2120 0 0 {name=l1002 sig_type=std_logic lab=_233__A}
N 3270 2100 3310 2100 {lab=_234__B}
C {lab_pin.sym} 3310 2100 0 1 {name=l1004 sig_type=std_logic lab=_234__B}
C {sg13cmos5l_tiehi.sym} 3770 2080 0 0 {name=X_269__90 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 2080 3730 2080 {lab=_269__90_L_HI}
C {lab_pin.sym} 3730 2080 0 0 {name=l1007 sig_type=std_logic lab=_269__90_L_HI}
C {sg13cmos5l_inv_1.sym} 4430 2080 0 0 {name=X_146_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 2080 4350 2080 {lab=_269__Q}
C {lab_pin.sym} 4350 2080 0 0 {name=l1010 sig_type=std_logic lab=_269__Q}
N 4470 2080 4510 2080 {lab=_146__Y}
C {lab_pin.sym} 4510 2080 0 1 {name=l1012 sig_type=std_logic lab=_146__Y}
C {sg13cmos5l_nor2_1.sym} 5070 2100 0 0 {name=X_215_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 2080 4970 2080 {lab=_215__A}
C {lab_pin.sym} 4970 2080 0 0 {name=l1015 sig_type=std_logic lab=_215__A}
N 5010 2120 4970 2120 {lab=_215__B}
C {lab_pin.sym} 4970 2120 0 0 {name=l1017 sig_type=std_logic lab=_215__B}
N 5130 2100 5170 2100 {lab=_216__C}
C {lab_pin.sym} 5170 2100 0 1 {name=l1019 sig_type=std_logic lab=_216__C}
C {sg13cmos5l_inv_1.sym} 5670 2080 0 0 {name=X_129_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 2080 5590 2080 {lab=_286__Q}
C {lab_pin.sym} 5590 2080 0 0 {name=l1022 sig_type=std_logic lab=_286__Q}
N 5710 2080 5750 2080 {lab=_129__Y}
C {lab_pin.sym} 5750 2080 0 1 {name=l1024 sig_type=std_logic lab=_129__Y}
C {sg13cmos5l_dlygate4sd3_1.sym} 6290 2080 0 0 {name=Xhold116 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 2080 6210 2080 {lab=_274__Q}
C {lab_pin.sym} 6210 2080 0 0 {name=l1027 sig_type=std_logic lab=_274__Q}
N 6330 2080 6370 2080 {lab=_215__B}
C {lab_pin.sym} 6370 2080 0 1 {name=l1029 sig_type=std_logic lab=_215__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 6910 2080 0 0 {name=Xhold127 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 2080 6830 2080 {lab=_177__Y}
C {lab_pin.sym} 6830 2080 0 0 {name=l1032 sig_type=std_logic lab=_177__Y}
N 6950 2080 6990 2080 {lab=_261__D}
C {lab_pin.sym} 6990 2080 0 1 {name=l1034 sig_type=std_logic lab=_261__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 7530 2080 0 0 {name=Xhold138 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 2080 7450 2080 {lab=_272__Q}
C {lab_pin.sym} 7450 2080 0 0 {name=l1037 sig_type=std_logic lab=_272__Q}
N 7570 2080 7610 2080 {lab=_209__B}
C {lab_pin.sym} 7610 2080 0 1 {name=l1039 sig_type=std_logic lab=_209__B}
C {sg13cmos5l_dlygate4sd3_1.sym} 710 2240 0 0 {name=Xhold149 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 2240 630 2240 {lab=_286__Q}
C {lab_pin.sym} 630 2240 0 0 {name=l1042 sig_type=std_logic lab=_286__Q}
N 750 2240 790 2240 {lab=_253__A}
C {lab_pin.sym} 790 2240 0 1 {name=l1044 sig_type=std_logic lab=_253__A}
C {sg13cmos5l_buf_1.sym} 1330 2240 0 0 {name=Xfanout77 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 2240 1250 2240 {lab=_206__A}
C {lab_pin.sym} 1250 2240 0 0 {name=l1047 sig_type=std_logic lab=_206__A}
N 1370 2240 1410 2240 {lab=_200__A}
C {lab_pin.sym} 1410 2240 0 1 {name=l1049 sig_type=std_logic lab=_200__A}
C {sg13cmos5l_nor3_1.sym} 1970 2280 0 0 {name=X_231_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 2240 1870 2240 {lab=_243__A}
C {lab_pin.sym} 1870 2240 0 0 {name=l1052 sig_type=std_logic lab=_243__A}
N 1910 2280 1870 2280 {lab=_231__B}
C {lab_pin.sym} 1870 2280 0 0 {name=l1054 sig_type=std_logic lab=_231__B}
N 1910 2320 1870 2320 {lab=_231__C}
C {lab_pin.sym} 1870 2320 0 0 {name=l1056 sig_type=std_logic lab=_231__C}
N 2030 2280 2070 2280 {lab=_231__Y}
C {lab_pin.sym} 2070 2280 0 1 {name=l1058 sig_type=std_logic lab=_231__Y}
C {sg13cmos5l_nor3_1.sym} 2590 2280 0 0 {name=X_162_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 2240 2490 2240 {lab=_252__A}
C {lab_pin.sym} 2490 2240 0 0 {name=l1061 sig_type=std_logic lab=_252__A}
N 2530 2280 2490 2280 {lab=_162__B}
C {lab_pin.sym} 2490 2280 0 0 {name=l1063 sig_type=std_logic lab=_162__B}
N 2530 2320 2490 2320 {lab=_162__C}
C {lab_pin.sym} 2490 2320 0 0 {name=l1065 sig_type=std_logic lab=_162__C}
N 2650 2280 2690 2280 {lab=_162__Y}
C {lab_pin.sym} 2690 2280 0 1 {name=l1067 sig_type=std_logic lab=_162__Y}
C {sg13cmos5l_buf_1.sym} 3190 2240 0 0 {name=Xinput1 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 2240 3110 2240 {lab=reset}
C {lab_pin.sym} 3110 2240 0 0 {name=l1070 sig_type=std_logic lab=reset}
N 3230 2240 3270 2240 {lab=input1_X}
C {lab_pin.sym} 3270 2240 0 1 {name=l1072 sig_type=std_logic lab=input1_X}
C {sg13cmos5l_nor2b_1.sym} 3830 2260 0 0 {name=X_214_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 2240 3730 2240 {lab=_273__Q}
C {lab_pin.sym} 3730 2240 0 0 {name=l1075 sig_type=std_logic lab=_273__Q}
N 3770 2280 3730 2280 {lab=_215__A}
C {lab_pin.sym} 3730 2280 0 0 {name=l1077 sig_type=std_logic lab=_215__A}
N 3890 2260 3930 2260 {lab=_216__B}
C {lab_pin.sym} 3930 2260 0 1 {name=l1079 sig_type=std_logic lab=_216__B}
C {sg13cmos5l_inv_1.sym} 4430 2240 0 0 {name=X_145_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 2240 4350 2240 {lab=_270__Q}
C {lab_pin.sym} 4350 2240 0 0 {name=l1082 sig_type=std_logic lab=_270__Q}
N 4470 2240 4510 2240 {lab=_145__Y}
C {lab_pin.sym} 4510 2240 0 1 {name=l1084 sig_type=std_logic lab=_145__Y}
C {sg13cmos5l_inv_1.sym} 5050 2240 0 0 {name=X_128_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 2240 4970 2240 {lab=_287__Q}
C {lab_pin.sym} 4970 2240 0 0 {name=l1087 sig_type=std_logic lab=_287__Q}
N 5090 2240 5130 2240 {lab=_128__Y}
C {lab_pin.sym} 5130 2240 0 1 {name=l1089 sig_type=std_logic lab=_128__Y}
C {sg13cmos5l_dlygate4sd3_1.sym} 5670 2240 0 0 {name=Xhold117 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 2240 5590 2240 {lab=_216__Y}
C {lab_pin.sym} 5590 2240 0 0 {name=l1092 sig_type=std_logic lab=_216__Y}
N 5710 2240 5750 2240 {lab=_274__D}
C {lab_pin.sym} 5750 2240 0 1 {name=l1094 sig_type=std_logic lab=_274__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 6290 2240 0 0 {name=Xhold139 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 2240 6210 2240 {lab=_210__Y}
C {lab_pin.sym} 6210 2240 0 0 {name=l1097 sig_type=std_logic lab=_210__Y}
N 6330 2240 6370 2240 {lab=_272__D}
C {lab_pin.sym} 6370 2240 0 1 {name=l1099 sig_type=std_logic lab=_272__D}
C {sg13cmos5l_dlygate4sd3_1.sym} 6910 2240 0 0 {name=Xhold128 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 2240 6830 2240 {lab=_269__Q}
C {lab_pin.sym} 6830 2240 0 0 {name=l1102 sig_type=std_logic lab=_269__Q}
N 6950 2240 6990 2240 {lab=_202__A}
C {lab_pin.sym} 6990 2240 0 1 {name=l1104 sig_type=std_logic lab=_202__A}
C {sg13cmos5l_buf_1.sym} 7530 2240 0 0 {name=Xfanout78 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 2240 7450 2240 {lab=input3_X}
C {lab_pin.sym} 7450 2240 0 0 {name=l1107 sig_type=std_logic lab=input3_X}
N 7570 2240 7610 2240 {lab=_206__A}
C {lab_pin.sym} 7610 2240 0 1 {name=l1109 sig_type=std_logic lab=_206__A}
C {sg13cmos5l_nor2_1.sym} 730 2420 0 0 {name=X_230_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 2400 630 2400 {lab=_233__A}
C {lab_pin.sym} 630 2400 0 0 {name=l1112 sig_type=std_logic lab=_233__A}
N 670 2440 630 2440 {lab=_230__B}
C {lab_pin.sym} 630 2440 0 0 {name=l1114 sig_type=std_logic lab=_230__B}
N 790 2420 830 2420 {lab=_231__C}
C {lab_pin.sym} 830 2420 0 1 {name=l1116 sig_type=std_logic lab=_231__C}
C {sg13cmos5l_nor2_1.sym} 1350 2420 0 0 {name=X_161_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 2400 1250 2400 {lab=_251__B}
C {lab_pin.sym} 1250 2400 0 0 {name=l1119 sig_type=std_logic lab=_251__B}
N 1290 2440 1250 2440 {lab=_161__B}
C {lab_pin.sym} 1250 2440 0 0 {name=l1121 sig_type=std_logic lab=_161__B}
N 1410 2420 1450 2420 {lab=_162__C}
C {lab_pin.sym} 1450 2420 0 1 {name=l1123 sig_type=std_logic lab=_162__C}
C {sg13cmos5l_buf_1.sym} 1950 2400 0 0 {name=Xinput2 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 2400 1870 2400 {lab=serial_in_data}
C {lab_pin.sym} 1870 2400 0 0 {name=l1126 sig_type=std_logic lab=serial_in_data}
N 1990 2400 2030 2400 {lab=_217__A}
C {lab_pin.sym} 2030 2400 0 1 {name=l1128 sig_type=std_logic lab=_217__A}
C {sg13cmos5l_nor3_1.sym} 2590 2440 0 0 {name=X_213_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 2400 2490 2400 {lab=_213__A}
C {lab_pin.sym} 2490 2400 0 0 {name=l1131 sig_type=std_logic lab=_213__A}
N 2530 2440 2490 2440 {lab=_213__B}
C {lab_pin.sym} 2490 2440 0 0 {name=l1133 sig_type=std_logic lab=_213__B}
N 2530 2480 2490 2480 {lab=_213__C}
C {lab_pin.sym} 2490 2480 0 0 {name=l1135 sig_type=std_logic lab=_213__C}
N 2650 2440 2690 2440 {lab=_213__Y}
C {lab_pin.sym} 2690 2440 0 1 {name=l1137 sig_type=std_logic lab=_213__Y}
C {sg13cmos5l_inv_1.sym} 3190 2400 0 0 {name=X_144_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 2400 3110 2400 {lab=_271__Q}
C {lab_pin.sym} 3110 2400 0 0 {name=l1140 sig_type=std_logic lab=_271__Q}
N 3230 2400 3270 2400 {lab=_144__Y}
C {lab_pin.sym} 3270 2400 0 1 {name=l1142 sig_type=std_logic lab=_144__Y}
C {sg13cmos5l_dlygate4sd3_1.sym} 3810 2400 0 0 {name=Xhold118 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 2400 3730 2400 {lab=_282__Q}
C {lab_pin.sym} 3730 2400 0 0 {name=l1145 sig_type=std_logic lab=_282__Q}
N 3850 2400 3890 2400 {lab=_241__A}
C {lab_pin.sym} 3890 2400 0 1 {name=l1147 sig_type=std_logic lab=_241__A}
C {sg13cmos5l_dlygate4sd3_1.sym} 4430 2400 0 0 {name=Xhold129 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 2400 4350 2400 {lab=_201__Y}
C {lab_pin.sym} 4350 2400 0 0 {name=l1150 sig_type=std_logic lab=_201__Y}
N 4470 2400 4510 2400 {lab=_269__D}
C {lab_pin.sym} 4510 2400 0 1 {name=l1152 sig_type=std_logic lab=_269__D}
C {sg13cmos5l_buf_1.sym} 5050 2400 0 0 {name=Xfanout79 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 2400 4970 2400 {lab=_252__A}
C {lab_pin.sym} 4970 2400 0 0 {name=l1155 sig_type=std_logic lab=_252__A}
N 5090 2400 5130 2400 {lab=_243__A}
C {lab_pin.sym} 5130 2400 0 1 {name=l1157 sig_type=std_logic lab=_243__A}
C {sg13cmos5l_buf_1.sym} 5670 2400 0 0 {name=Xfanout68 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 2400 5590 2400 {lab=_245__A}
C {lab_pin.sym} 5590 2400 0 0 {name=l1160 sig_type=std_logic lab=_245__A}
N 5710 2400 5750 2400 {lab=_233__A}
C {lab_pin.sym} 5750 2400 0 1 {name=l1162 sig_type=std_logic lab=_233__A}
C {sg13cmos5l_nor2b_1.sym} 6310 2420 0 0 {name=X_160_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 2400 6210 2400 {lab=_287__Q}
C {lab_pin.sym} 6210 2400 0 0 {name=l1165 sig_type=std_logic lab=_287__Q}
N 6250 2440 6210 2440 {lab=_251__B}
C {lab_pin.sym} 6210 2440 0 0 {name=l1167 sig_type=std_logic lab=_251__B}
N 6370 2420 6410 2420 {lab=_162__B}
C {lab_pin.sym} 6410 2420 0 1 {name=l1169 sig_type=std_logic lab=_162__B}
C {sg13cmos5l_tiehi.sym} 6870 2400 0 0 {name=X_278__93 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 2400 6830 2400 {lab=_278__93_L_HI}
C {lab_pin.sym} 6830 2400 0 0 {name=l1172 sig_type=std_logic lab=_278__93_L_HI}
C {sg13cmos5l_buf_1.sym} 7530 2400 0 0 {name=Xinput3 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 2400 7450 2400 {lab=shift_enable}
C {lab_pin.sym} 7450 2400 0 0 {name=l1175 sig_type=std_logic lab=shift_enable}
N 7570 2400 7610 2400 {lab=input3_X}
C {lab_pin.sym} 7610 2400 0 1 {name=l1177 sig_type=std_logic lab=input3_X}
C {sg13cmos5l_nor2_1.sym} 730 2580 0 0 {name=X_212_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 2560 630 2560 {lab=_215__A}
C {lab_pin.sym} 630 2560 0 0 {name=l1180 sig_type=std_logic lab=_215__A}
N 670 2600 630 2600 {lab=_212__B}
C {lab_pin.sym} 630 2600 0 0 {name=l1182 sig_type=std_logic lab=_212__B}
N 790 2580 830 2580 {lab=_213__C}
C {lab_pin.sym} 830 2580 0 1 {name=l1184 sig_type=std_logic lab=_213__C}
C {sg13cmos5l_inv_1.sym} 1330 2560 0 0 {name=X_143_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 2560 1250 2560 {lab=_272__Q}
C {lab_pin.sym} 1250 2560 0 0 {name=l1187 sig_type=std_logic lab=_272__Q}
N 1370 2560 1410 2560 {lab=_143__Y}
C {lab_pin.sym} 1410 2560 0 1 {name=l1189 sig_type=std_logic lab=_143__Y}
C {sg13cmos5l_tiehi.sym} 1910 2560 0 0 {name=X_266__96 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 2560 1870 2560 {lab=_266__96_L_HI}
C {lab_pin.sym} 1870 2560 0 0 {name=l1192 sig_type=std_logic lab=_266__96_L_HI}
C {sg13cmos5l_tiehi.sym} 2530 2560 0 0 {name=X_273__113 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 2560 2490 2560 {lab=_273__RESET_B}
C {lab_pin.sym} 2490 2560 0 0 {name=l1195 sig_type=std_logic lab=_273__RESET_B}
C {sg13cmos5l_dlygate4sd3_1.sym} 3190 2560 0 0 {name=Xhold119 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 2560 3110 2560 {lab=_240__Y}
C {lab_pin.sym} 3110 2560 0 0 {name=l1198 sig_type=std_logic lab=_240__Y}
N 3230 2560 3270 2560 {lab=_282__D}
C {lab_pin.sym} 3270 2560 0 1 {name=l1200 sig_type=std_logic lab=_282__D}
C {sg13cmos5l_buf_1.sym} 3810 2560 0 0 {name=Xfanout69 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 2560 3730 2560 {lab=_245__A}
C {lab_pin.sym} 3730 2560 0 0 {name=l1203 sig_type=std_logic lab=_245__A}
N 3850 2560 3890 2560 {lab=_224__A}
C {lab_pin.sym} 3890 2560 0 1 {name=l1205 sig_type=std_logic lab=_224__A}
C {sg13cmos5l_nor2b_1.sym} 4450 2580 0 0 {name=X_211_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 2560 4350 2560 {lab=_272__Q}
C {lab_pin.sym} 4350 2560 0 0 {name=l1208 sig_type=std_logic lab=_272__Q}
N 4390 2600 4350 2600 {lab=_215__A}
C {lab_pin.sym} 4350 2600 0 0 {name=l1210 sig_type=std_logic lab=_215__A}
N 4510 2580 4550 2580 {lab=_213__B}
C {lab_pin.sym} 4550 2580 0 1 {name=l1212 sig_type=std_logic lab=_213__B}
C {sg13cmos5l_inv_1.sym} 5050 2560 0 0 {name=X_142_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 2560 4970 2560 {lab=_273__Q}
C {lab_pin.sym} 4970 2560 0 0 {name=l1215 sig_type=std_logic lab=_273__Q}
N 5090 2560 5130 2560 {lab=_142__Y}
C {lab_pin.sym} 5130 2560 0 1 {name=l1217 sig_type=std_logic lab=_142__Y}
C {sg13cmos5l_tiehi.sym} 5630 2560 0 0 {name=X_263__102 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 2560 5590 2560 {lab=_263__RESET_B}
C {lab_pin.sym} 5590 2560 0 0 {name=l1220 sig_type=std_logic lab=_263__RESET_B}
C {sg13cmos5l_dfrbpq_1.sym} 6340 2580 0 0 {name=X_287_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 2560 6210 2560 {lab=clk}
C {lab_pin.sym} 6210 2560 0 0 {name=l1223 sig_type=std_logic lab=clk}
N 6250 2580 6210 2580 {lab=_287__D}
C {lab_pin.sym} 6210 2580 0 0 {name=l1225 sig_type=std_logic lab=_287__D}
N 6250 2600 6210 2600 {lab=_287__99_L_HI}
C {lab_pin.sym} 6210 2600 0 0 {name=l1227 sig_type=std_logic lab=_287__99_L_HI}
N 6430 2560 6470 2560 {lab=_287__Q}
C {lab_pin.sym} 6470 2560 0 1 {name=l1229 sig_type=std_logic lab=_287__Q}
C {sg13cmos5l_tiehi.sym} 6870 2560 0 0 {name=X_284__87 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 2560 6830 2560 {lab=_284__87_L_HI}
C {lab_pin.sym} 6830 2560 0 0 {name=l1232 sig_type=std_logic lab=_284__87_L_HI}
C {sg13cmos5l_tiehi.sym} 7490 2560 0 0 {name=X_276__101 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 2560 7450 2560 {lab=_276__RESET_B}
C {lab_pin.sym} 7450 2560 0 0 {name=l1235 sig_type=std_logic lab=_276__RESET_B}
C {sg13cmos5l_nor3_1.sym} 730 2760 0 0 {name=X_210_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 2720 630 2720 {lab=_213__A}
C {lab_pin.sym} 630 2720 0 0 {name=l1238 sig_type=std_logic lab=_213__A}
N 670 2760 630 2760 {lab=_210__B}
C {lab_pin.sym} 630 2760 0 0 {name=l1240 sig_type=std_logic lab=_210__B}
N 670 2800 630 2800 {lab=_210__C}
C {lab_pin.sym} 630 2800 0 0 {name=l1242 sig_type=std_logic lab=_210__C}
N 790 2760 830 2760 {lab=_210__Y}
C {lab_pin.sym} 830 2760 0 1 {name=l1244 sig_type=std_logic lab=_210__Y}
C {sg13cmos5l_inv_1.sym} 1330 2720 0 0 {name=X_141_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 2720 1250 2720 {lab=_274__Q}
C {lab_pin.sym} 1250 2720 0 0 {name=l1247 sig_type=std_logic lab=_274__Q}
N 1370 2720 1410 2720 {lab=_141__Y}
C {lab_pin.sym} 1410 2720 0 1 {name=l1249 sig_type=std_logic lab=_141__Y}
C {sg13cmos5l_dfrbpq_1.sym} 2000 2740 0 0 {name=X_286_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 2720 1870 2720 {lab=clk}
C {lab_pin.sym} 1870 2720 0 0 {name=l1252 sig_type=std_logic lab=clk}
N 1910 2740 1870 2740 {lab=_286__D}
C {lab_pin.sym} 1870 2740 0 0 {name=l1254 sig_type=std_logic lab=_286__D}
N 1910 2760 1870 2760 {lab=_286__91_L_HI}
C {lab_pin.sym} 1870 2760 0 0 {name=l1256 sig_type=std_logic lab=_286__91_L_HI}
N 2090 2720 2130 2720 {lab=_286__Q}
C {lab_pin.sym} 2130 2720 0 1 {name=l1258 sig_type=std_logic lab=_286__Q}
C {sg13cmos5l_inv_1.sym} 2570 2720 0 0 {name=X_140_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 2720 2490 2720 {lab=_275__Q}
C {lab_pin.sym} 2490 2720 0 0 {name=l1261 sig_type=std_logic lab=_275__Q}
N 2610 2720 2650 2720 {lab=_140__Y}
C {lab_pin.sym} 2650 2720 0 1 {name=l1263 sig_type=std_logic lab=_140__Y}
C {sg13cmos5l_dfrbpq_1.sym} 3240 2740 0 0 {name=X_269_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 2720 3110 2720 {lab=clk}
C {lab_pin.sym} 3110 2720 0 0 {name=l1266 sig_type=std_logic lab=clk}
N 3150 2740 3110 2740 {lab=_269__D}
C {lab_pin.sym} 3110 2740 0 0 {name=l1268 sig_type=std_logic lab=_269__D}
N 3150 2760 3110 2760 {lab=_269__90_L_HI}
C {lab_pin.sym} 3110 2760 0 0 {name=l1270 sig_type=std_logic lab=_269__90_L_HI}
N 3330 2720 3370 2720 {lab=_269__Q}
C {lab_pin.sym} 3370 2720 0 1 {name=l1272 sig_type=std_logic lab=_269__Q}
C {sg13cmos5l_dfrbpq_1.sym} 3860 2740 0 0 {name=X_285_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 2720 3730 2720 {lab=clk}
C {lab_pin.sym} 3730 2720 0 0 {name=l1275 sig_type=std_logic lab=clk}
N 3770 2740 3730 2740 {lab=_285__D}
C {lab_pin.sym} 3730 2740 0 0 {name=l1277 sig_type=std_logic lab=_285__D}
N 3770 2760 3730 2760 {lab=_285__RESET_B}
C {lab_pin.sym} 3730 2760 0 0 {name=l1279 sig_type=std_logic lab=_285__RESET_B}
N 3950 2720 3990 2720 {lab=_285__Q}
C {lab_pin.sym} 3990 2720 0 1 {name=l1281 sig_type=std_logic lab=_285__Q}
C {sg13cmos5l_nor2b_1.sym} 4450 2740 0 0 {name=X_199_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 2720 4350 2720 {lab=_268__Q}
C {lab_pin.sym} 4350 2720 0 0 {name=l1284 sig_type=std_logic lab=_268__Q}
N 4390 2760 4350 2760 {lab=_200__A}
C {lab_pin.sym} 4350 2760 0 0 {name=l1286 sig_type=std_logic lab=_200__A}
N 4510 2740 4550 2740 {lab=_201__B}
C {lab_pin.sym} 4550 2740 0 1 {name=l1288 sig_type=std_logic lab=_201__B}
C {sg13cmos5l_dfrbpq_1.sym} 5100 2740 0 0 {name=X_268_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 2720 4970 2720 {lab=clk}
C {lab_pin.sym} 4970 2720 0 0 {name=l1291 sig_type=std_logic lab=clk}
N 5010 2740 4970 2740 {lab=_268__D}
C {lab_pin.sym} 4970 2740 0 0 {name=l1293 sig_type=std_logic lab=_268__D}
N 5010 2760 4970 2760 {lab=_268__92_L_HI}
C {lab_pin.sym} 4970 2760 0 0 {name=l1295 sig_type=std_logic lab=_268__92_L_HI}
N 5190 2720 5230 2720 {lab=_268__Q}
C {lab_pin.sym} 5230 2720 0 1 {name=l1297 sig_type=std_logic lab=_268__Q}
C {sg13cmos5l_tiehi.sym} 5630 2720 0 0 {name=X_260__108 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 2720 5590 2720 {lab=_260__RESET_B}
C {lab_pin.sym} 5590 2720 0 0 {name=l1300 sig_type=std_logic lab=_260__RESET_B}
C {sg13cmos5l_dfrbpq_1.sym} 6340 2740 0 0 {name=X_284_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 2720 6210 2720 {lab=clk}
C {lab_pin.sym} 6210 2720 0 0 {name=l1303 sig_type=std_logic lab=clk}
N 6250 2740 6210 2740 {lab=_284__D}
C {lab_pin.sym} 6210 2740 0 0 {name=l1305 sig_type=std_logic lab=_284__D}
N 6250 2760 6210 2760 {lab=_284__87_L_HI}
C {lab_pin.sym} 6210 2760 0 0 {name=l1307 sig_type=std_logic lab=_284__87_L_HI}
N 6430 2720 6470 2720 {lab=_284__Q}
C {lab_pin.sym} 6470 2720 0 1 {name=l1309 sig_type=std_logic lab=_284__Q}
C {sg13cmos5l_dfrbpq_1.sym} 6960 2740 0 0 {name=X_267_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 2720 6830 2720 {lab=clk}
C {lab_pin.sym} 6830 2720 0 0 {name=l1312 sig_type=std_logic lab=clk}
N 6870 2740 6830 2740 {lab=_267__D}
C {lab_pin.sym} 6830 2740 0 0 {name=l1314 sig_type=std_logic lab=_267__D}
N 6870 2760 6830 2760 {lab=_267__94_L_HI}
C {lab_pin.sym} 6830 2760 0 0 {name=l1316 sig_type=std_logic lab=_267__94_L_HI}
N 7050 2720 7090 2720 {lab=_267__Q}
C {lab_pin.sym} 7090 2720 0 1 {name=l1318 sig_type=std_logic lab=_267__Q}
C {sg13cmos5l_nor3_1.sym} 7550 2760 0 0 {name=X_198_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 2720 7450 2720 {lab=_213__A}
C {lab_pin.sym} 7450 2720 0 0 {name=l1321 sig_type=std_logic lab=_213__A}
N 7490 2760 7450 2760 {lab=_198__B}
C {lab_pin.sym} 7450 2760 0 0 {name=l1323 sig_type=std_logic lab=_198__B}
N 7490 2800 7450 2800 {lab=_198__C}
C {lab_pin.sym} 7450 2800 0 0 {name=l1325 sig_type=std_logic lab=_198__C}
N 7610 2760 7650 2760 {lab=_268__D}
C {lab_pin.sym} 7650 2760 0 1 {name=l1327 sig_type=std_logic lab=_268__D}
C {sg13cmos5l_tiehi.sym} 670 2880 0 0 {name=X_259__110 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 2880 630 2880 {lab=_259__RESET_B}
C {lab_pin.sym} 630 2880 0 0 {name=l1330 sig_type=std_logic lab=_259__RESET_B}
C {sg13cmos5l_tiehi.sym} 1290 2880 0 0 {name=X_287__99 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 2880 1250 2880 {lab=_287__99_L_HI}
C {lab_pin.sym} 1250 2880 0 0 {name=l1333 sig_type=std_logic lab=_287__99_L_HI}
C {sg13cmos5l_dfrbpq_1.sym} 2000 2900 0 0 {name=X_283_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 2880 1870 2880 {lab=clk}
C {lab_pin.sym} 1870 2880 0 0 {name=l1336 sig_type=std_logic lab=clk}
N 1910 2900 1870 2900 {lab=_283__D}
C {lab_pin.sym} 1870 2900 0 0 {name=l1338 sig_type=std_logic lab=_283__D}
N 1910 2920 1870 2920 {lab=_283__95_L_HI}
C {lab_pin.sym} 1870 2920 0 0 {name=l1340 sig_type=std_logic lab=_283__95_L_HI}
N 2090 2880 2130 2880 {lab=_283__Q}
C {lab_pin.sym} 2130 2880 0 1 {name=l1342 sig_type=std_logic lab=_283__Q}
C {sg13cmos5l_nor2_1.sym} 2590 2900 0 0 {name=X_197_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 2880 2490 2880 {lab=_215__A}
C {lab_pin.sym} 2490 2880 0 0 {name=l1345 sig_type=std_logic lab=_215__A}
N 2530 2920 2490 2920 {lab=_197__B}
C {lab_pin.sym} 2490 2920 0 0 {name=l1347 sig_type=std_logic lab=_197__B}
N 2650 2900 2690 2900 {lab=_198__C}
C {lab_pin.sym} 2690 2900 0 1 {name=l1349 sig_type=std_logic lab=_198__C}
C {sg13cmos5l_dfrbpq_1.sym} 3240 2900 0 0 {name=X_266_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 2880 3110 2880 {lab=clk}
C {lab_pin.sym} 3110 2880 0 0 {name=l1352 sig_type=std_logic lab=clk}
N 3150 2900 3110 2900 {lab=_266__D}
C {lab_pin.sym} 3110 2900 0 0 {name=l1354 sig_type=std_logic lab=_266__D}
N 3150 2920 3110 2920 {lab=_266__96_L_HI}
C {lab_pin.sym} 3110 2920 0 0 {name=l1356 sig_type=std_logic lab=_266__96_L_HI}
N 3330 2880 3370 2880 {lab=_266__Q}
C {lab_pin.sym} 3370 2880 0 1 {name=l1358 sig_type=std_logic lab=_266__Q}
C {sg13cmos5l_nor3_1.sym} 3830 2920 0 0 {name=X_249_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 2880 3730 2880 {lab=_252__A}
C {lab_pin.sym} 3730 2880 0 0 {name=l1361 sig_type=std_logic lab=_252__A}
N 3770 2920 3730 2920 {lab=_249__B}
C {lab_pin.sym} 3730 2920 0 0 {name=l1363 sig_type=std_logic lab=_249__B}
N 3770 2960 3730 2960 {lab=_249__C}
C {lab_pin.sym} 3730 2960 0 0 {name=l1365 sig_type=std_logic lab=_249__C}
N 3890 2920 3930 2920 {lab=_285__D}
C {lab_pin.sym} 3930 2920 0 1 {name=l1367 sig_type=std_logic lab=_285__D}
C {sg13cmos5l_dfrbpq_1.sym} 4480 2900 0 0 {name=X_282_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 2880 4350 2880 {lab=clk}
C {lab_pin.sym} 4350 2880 0 0 {name=l1370 sig_type=std_logic lab=clk}
N 4390 2900 4350 2900 {lab=_282__D}
C {lab_pin.sym} 4350 2900 0 0 {name=l1372 sig_type=std_logic lab=_282__D}
N 4390 2920 4350 2920 {lab=_282__RESET_B}
C {lab_pin.sym} 4350 2920 0 0 {name=l1374 sig_type=std_logic lab=_282__RESET_B}
N 4570 2880 4610 2880 {lab=_282__Q}
C {lab_pin.sym} 4610 2880 0 1 {name=l1376 sig_type=std_logic lab=_282__Q}
C {sg13cmos5l_dfrbpq_1.sym} 5100 2900 0 0 {name=X_265_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 2880 4970 2880 {lab=clk}
C {lab_pin.sym} 4970 2880 0 0 {name=l1379 sig_type=std_logic lab=clk}
N 5010 2900 4970 2900 {lab=_265__D}
C {lab_pin.sym} 4970 2900 0 0 {name=l1381 sig_type=std_logic lab=_265__D}
N 5010 2920 4970 2920 {lab=_265__98_L_HI}
C {lab_pin.sym} 4970 2920 0 0 {name=l1383 sig_type=std_logic lab=_265__98_L_HI}
N 5190 2880 5230 2880 {lab=_265__Q}
C {lab_pin.sym} 5230 2880 0 1 {name=l1385 sig_type=std_logic lab=_265__Q}
C {sg13cmos5l_nor2b_1.sym} 5690 2900 0 0 {name=X_196_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 2880 5590 2880 {lab=_196__A}
C {lab_pin.sym} 5590 2880 0 0 {name=l1388 sig_type=std_logic lab=_196__A}
N 5630 2920 5590 2920 {lab=_200__A}
C {lab_pin.sym} 5590 2920 0 0 {name=l1390 sig_type=std_logic lab=_200__A}
N 5750 2900 5790 2900 {lab=_198__B}
C {lab_pin.sym} 5790 2900 0 1 {name=l1392 sig_type=std_logic lab=_198__B}
C {sg13cmos5l_nor2_1.sym} 6310 2900 0 0 {name=X_179_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 2880 6210 2880 {lab=_200__A}
C {lab_pin.sym} 6210 2880 0 0 {name=l1395 sig_type=std_logic lab=_200__A}
N 6250 2920 6210 2920 {lab=_181__A}
C {lab_pin.sym} 6210 2920 0 0 {name=l1397 sig_type=std_logic lab=_181__A}
N 6370 2900 6410 2900 {lab=_180__C}
C {lab_pin.sym} 6410 2900 0 1 {name=l1399 sig_type=std_logic lab=_180__C}
C {sg13cmos5l_nor2_1.sym} 6930 2900 0 0 {name=X_248_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 2880 6830 2880 {lab=_251__B}
C {lab_pin.sym} 6830 2880 0 0 {name=l1402 sig_type=std_logic lab=_251__B}
N 6870 2920 6830 2920 {lab=_250__A}
C {lab_pin.sym} 6830 2920 0 0 {name=l1404 sig_type=std_logic lab=_250__A}
N 6990 2900 7030 2900 {lab=_249__C}
C {lab_pin.sym} 7030 2900 0 1 {name=l1406 sig_type=std_logic lab=_249__C}
C {sg13cmos5l_tiehi.sym} 7490 2880 0 0 {name=X_256__115 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 2880 7450 2880 {lab=_256__RESET_B}
C {lab_pin.sym} 7450 2880 0 0 {name=l1409 sig_type=std_logic lab=_256__RESET_B}
C {sg13cmos5l_dfrbpq_1.sym} 760 3060 0 0 {name=X_281_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 3040 630 3040 {lab=clk}
C {lab_pin.sym} 630 3040 0 0 {name=l1412 sig_type=std_logic lab=clk}
N 670 3060 630 3060 {lab=_281__D}
C {lab_pin.sym} 630 3060 0 0 {name=l1414 sig_type=std_logic lab=_281__D}
N 670 3080 630 3080 {lab=_281__RESET_B}
C {lab_pin.sym} 630 3080 0 0 {name=l1416 sig_type=std_logic lab=_281__RESET_B}
N 850 3040 890 3040 {lab=_281__Q}
C {lab_pin.sym} 890 3040 0 1 {name=l1418 sig_type=std_logic lab=_281__Q}
C {sg13cmos5l_dfrbpq_1.sym} 1380 3060 0 0 {name=X_264_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 3040 1250 3040 {lab=clk}
C {lab_pin.sym} 1250 3040 0 0 {name=l1421 sig_type=std_logic lab=clk}
N 1290 3060 1250 3060 {lab=_264__D}
C {lab_pin.sym} 1250 3060 0 0 {name=l1423 sig_type=std_logic lab=_264__D}
N 1290 3080 1250 3080 {lab=_264__RESET_B}
C {lab_pin.sym} 1250 3080 0 0 {name=l1425 sig_type=std_logic lab=_264__RESET_B}
N 1470 3040 1510 3040 {lab=_264__Q}
C {lab_pin.sym} 1510 3040 0 1 {name=l1427 sig_type=std_logic lab=_264__Q}
C {sg13cmos5l_nor3_1.sym} 1970 3080 0 0 {name=X_195_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 3040 1870 3040 {lab=_195__A}
C {lab_pin.sym} 1870 3040 0 0 {name=l1430 sig_type=std_logic lab=_195__A}
N 1910 3080 1870 3080 {lab=_195__B}
C {lab_pin.sym} 1870 3080 0 0 {name=l1432 sig_type=std_logic lab=_195__B}
N 1910 3120 1870 3120 {lab=_195__C}
C {lab_pin.sym} 1870 3120 0 0 {name=l1434 sig_type=std_logic lab=_195__C}
N 2030 3080 2070 3080 {lab=_195__Y}
C {lab_pin.sym} 2070 3080 0 1 {name=l1436 sig_type=std_logic lab=_195__Y}
C {sg13cmos5l_tiehi.sym} 2530 3040 0 0 {name=X_280__85 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 3040 2490 3040 {lab=_280__85_L_HI}
C {lab_pin.sym} 2490 3040 0 0 {name=l1439 sig_type=std_logic lab=_280__85_L_HI}
C {sg13cmos5l_nor2b_1.sym} 3210 3060 0 0 {name=X_247_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 3040 3110 3040 {lab=_247__A}
C {lab_pin.sym} 3110 3040 0 0 {name=l1442 sig_type=std_logic lab=_247__A}
N 3150 3080 3110 3080 {lab=_247__B_N}
C {lab_pin.sym} 3110 3080 0 0 {name=l1444 sig_type=std_logic lab=_247__B_N}
N 3270 3060 3310 3060 {lab=_249__B}
C {lab_pin.sym} 3310 3060 0 1 {name=l1446 sig_type=std_logic lab=_249__B}
C {sg13cmos5l_nor2b_1.sym} 3830 3060 0 0 {name=X_178_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 3040 3730 3040 {lab=_178__A}
C {lab_pin.sym} 3730 3040 0 0 {name=l1449 sig_type=std_logic lab=_178__A}
N 3770 3080 3730 3080 {lab=_176__A}
C {lab_pin.sym} 3730 3080 0 0 {name=l1451 sig_type=std_logic lab=_176__A}
N 3890 3060 3930 3060 {lab=_180__B}
C {lab_pin.sym} 3930 3060 0 1 {name=l1453 sig_type=std_logic lab=_180__B}
C {sg13cmos5l_dfrbpq_1.sym} 4480 3060 0 0 {name=X_280_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 3040 4350 3040 {lab=clk}
C {lab_pin.sym} 4350 3040 0 0 {name=l1456 sig_type=std_logic lab=clk}
N 4390 3060 4350 3060 {lab=_280__D}
C {lab_pin.sym} 4350 3060 0 0 {name=l1458 sig_type=std_logic lab=_280__D}
N 4390 3080 4350 3080 {lab=_280__85_L_HI}
C {lab_pin.sym} 4350 3080 0 0 {name=l1460 sig_type=std_logic lab=_280__85_L_HI}
N 4570 3040 4610 3040 {lab=_280__Q}
C {lab_pin.sym} 4610 3040 0 1 {name=l1462 sig_type=std_logic lab=_280__Q}
C {sg13cmos5l_tiehi.sym} 5010 3040 0 0 {name=X_286__91 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 3040 4970 3040 {lab=_286__91_L_HI}
C {lab_pin.sym} 4970 3040 0 0 {name=l1465 sig_type=std_logic lab=_286__91_L_HI}
C {sg13cmos5l_dfrbpq_1.sym} 5720 3060 0 0 {name=X_263_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 3040 5590 3040 {lab=clk}
C {lab_pin.sym} 5590 3040 0 0 {name=l1468 sig_type=std_logic lab=clk}
N 5630 3060 5590 3060 {lab=_263__D}
C {lab_pin.sym} 5590 3060 0 0 {name=l1470 sig_type=std_logic lab=_263__D}
N 5630 3080 5590 3080 {lab=_263__RESET_B}
C {lab_pin.sym} 5590 3080 0 0 {name=l1472 sig_type=std_logic lab=_263__RESET_B}
N 5810 3040 5850 3040 {lab=_263__Q}
C {lab_pin.sym} 5850 3040 0 1 {name=l1474 sig_type=std_logic lab=_263__Q}
C {sg13cmos5l_nor2_1.sym} 6310 3060 0 0 {name=X_194_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 3040 6210 3040 {lab=_200__A}
C {lab_pin.sym} 6210 3040 0 0 {name=l1477 sig_type=std_logic lab=_200__A}
N 6250 3080 6210 3080 {lab=_196__A}
C {lab_pin.sym} 6210 3080 0 0 {name=l1479 sig_type=std_logic lab=_196__A}
N 6370 3060 6410 3060 {lab=_195__C}
C {lab_pin.sym} 6410 3060 0 1 {name=l1481 sig_type=std_logic lab=_195__C}
C {sg13cmos5l_tiehi.sym} 6870 3040 0 0 {name=X_271__86 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 3040 6830 3040 {lab=_271__86_L_HI}
C {lab_pin.sym} 6830 3040 0 0 {name=l1484 sig_type=std_logic lab=_271__86_L_HI}
C {sg13cmos5l_nor3_1.sym} 7550 3080 0 0 {name=X_177_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 3040 7450 3040 {lab=_195__A}
C {lab_pin.sym} 7450 3040 0 0 {name=l1487 sig_type=std_logic lab=_195__A}
N 7490 3080 7450 3080 {lab=_177__B}
C {lab_pin.sym} 7450 3080 0 0 {name=l1489 sig_type=std_logic lab=_177__B}
N 7490 3120 7450 3120 {lab=_177__C}
C {lab_pin.sym} 7450 3120 0 0 {name=l1491 sig_type=std_logic lab=_177__C}
N 7610 3080 7650 3080 {lab=_177__Y}
C {lab_pin.sym} 7650 3080 0 1 {name=l1493 sig_type=std_logic lab=_177__Y}
C {sg13cmos5l_nor3_1.sym} 730 3240 0 0 {name=X_246_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 3200 630 3200 {lab=_252__A}
C {lab_pin.sym} 630 3200 0 0 {name=l1496 sig_type=std_logic lab=_252__A}
N 670 3240 630 3240 {lab=_246__B}
C {lab_pin.sym} 630 3240 0 0 {name=l1498 sig_type=std_logic lab=_246__B}
N 670 3280 630 3280 {lab=_246__C}
C {lab_pin.sym} 630 3280 0 0 {name=l1500 sig_type=std_logic lab=_246__C}
N 790 3240 830 3240 {lab=_284__D}
C {lab_pin.sym} 830 3240 0 1 {name=l1502 sig_type=std_logic lab=_284__D}
C {sg13cmos5l_nor2b_1.sym} 1350 3220 0 0 {name=X_229_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 3200 1250 3200 {lab=_278__Q}
C {lab_pin.sym} 1250 3200 0 0 {name=l1505 sig_type=std_logic lab=_278__Q}
N 1290 3240 1250 3240 {lab=_233__A}
C {lab_pin.sym} 1250 3240 0 0 {name=l1507 sig_type=std_logic lab=_233__A}
N 1410 3220 1450 3220 {lab=_231__B}
C {lab_pin.sym} 1450 3220 0 1 {name=l1509 sig_type=std_logic lab=_231__B}
C {sg13cmos5l_tiehi.sym} 1910 3200 0 0 {name=X_268__92 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 3200 1870 3200 {lab=_268__92_L_HI}
C {lab_pin.sym} 1870 3200 0 0 {name=l1512 sig_type=std_logic lab=_268__92_L_HI}
C {sg13cmos5l_dfrbpq_1.sym} 2620 3220 0 0 {name=X_262_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 3200 2490 3200 {lab=clk}
C {lab_pin.sym} 2490 3200 0 0 {name=l1515 sig_type=std_logic lab=clk}
N 2530 3220 2490 3220 {lab=_262__D}
C {lab_pin.sym} 2490 3220 0 0 {name=l1517 sig_type=std_logic lab=_262__D}
N 2530 3240 2490 3240 {lab=_262__RESET_B}
C {lab_pin.sym} 2490 3240 0 0 {name=l1519 sig_type=std_logic lab=_262__RESET_B}
N 2710 3200 2750 3200 {lab=_262__Q}
C {lab_pin.sym} 2750 3200 0 1 {name=l1521 sig_type=std_logic lab=_262__Q}
C {sg13cmos5l_tiehi.sym} 3150 3200 0 0 {name=X_283__95 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 3200 3110 3200 {lab=_283__95_L_HI}
C {lab_pin.sym} 3110 3200 0 0 {name=l1524 sig_type=std_logic lab=_283__95_L_HI}
C {sg13cmos5l_nor2b_1.sym} 3830 3220 0 0 {name=X_193_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 3200 3730 3200 {lab=_266__Q}
C {lab_pin.sym} 3730 3200 0 0 {name=l1527 sig_type=std_logic lab=_266__Q}
N 3770 3240 3730 3240 {lab=_191__A}
C {lab_pin.sym} 3730 3240 0 0 {name=l1529 sig_type=std_logic lab=_191__A}
N 3890 3220 3930 3220 {lab=_195__B}
C {lab_pin.sym} 3930 3220 0 1 {name=l1531 sig_type=std_logic lab=_195__B}
C {sg13cmos5l_nor2_1.sym} 4450 3220 0 0 {name=X_176_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 3200 4350 3200 {lab=_176__A}
C {lab_pin.sym} 4350 3200 0 0 {name=l1534 sig_type=std_logic lab=_176__A}
N 4390 3240 4350 3240 {lab=_178__A}
C {lab_pin.sym} 4350 3240 0 0 {name=l1536 sig_type=std_logic lab=_178__A}
N 4510 3220 4550 3220 {lab=_177__C}
C {lab_pin.sym} 4550 3220 0 1 {name=l1538 sig_type=std_logic lab=_177__C}
C {sg13cmos5l_nor2_1.sym} 5070 3220 0 0 {name=X_245_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 3200 4970 3200 {lab=_245__A}
C {lab_pin.sym} 4970 3200 0 0 {name=l1541 sig_type=std_logic lab=_245__A}
N 5010 3240 4970 3240 {lab=_247__A}
C {lab_pin.sym} 4970 3240 0 0 {name=l1543 sig_type=std_logic lab=_247__A}
N 5130 3220 5170 3220 {lab=_246__C}
C {lab_pin.sym} 5170 3220 0 1 {name=l1545 sig_type=std_logic lab=_246__C}
C {sg13cmos5l_nor3_1.sym} 5690 3240 0 0 {name=X_228_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 3200 5590 3200 {lab=_243__A}
C {lab_pin.sym} 5590 3200 0 0 {name=l1548 sig_type=std_logic lab=_243__A}
N 5630 3240 5590 3240 {lab=_228__B}
C {lab_pin.sym} 5590 3240 0 0 {name=l1550 sig_type=std_logic lab=_228__B}
N 5630 3280 5590 3280 {lab=_228__C}
C {lab_pin.sym} 5590 3280 0 0 {name=l1552 sig_type=std_logic lab=_228__C}
N 5750 3240 5790 3240 {lab=_278__D}
C {lab_pin.sym} 5790 3240 0 1 {name=l1554 sig_type=std_logic lab=_278__D}
C {sg13cmos5l_inv_1.sym} 6290 3200 0 0 {name=X_159_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 3200 6210 3200 {lab=_256__Q}
C {lab_pin.sym} 6210 3200 0 0 {name=l1557 sig_type=std_logic lab=_256__Q}
N 6330 3200 6370 3200 {lab=_159__Y}
C {lab_pin.sym} 6370 3200 0 1 {name=l1559 sig_type=std_logic lab=_159__Y}
C {sg13cmos5l_dfrbpq_1.sym} 6960 3220 0 0 {name=X_261_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 3200 6830 3200 {lab=clk}
C {lab_pin.sym} 6830 3200 0 0 {name=l1562 sig_type=std_logic lab=clk}
N 6870 3220 6830 3220 {lab=_261__D}
C {lab_pin.sym} 6830 3220 0 0 {name=l1564 sig_type=std_logic lab=_261__D}
N 6870 3240 6830 3240 {lab=_261__RESET_B}
C {lab_pin.sym} 6830 3240 0 0 {name=l1566 sig_type=std_logic lab=_261__RESET_B}
N 7050 3200 7090 3200 {lab=_261__Q}
C {lab_pin.sym} 7090 3200 0 1 {name=l1568 sig_type=std_logic lab=_261__Q}
C {sg13cmos5l_nor3_1.sym} 7550 3240 0 0 {name=X_192_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 3200 7450 3200 {lab=_195__A}
C {lab_pin.sym} 7450 3200 0 0 {name=l1571 sig_type=std_logic lab=_195__A}
N 7490 3240 7450 3240 {lab=_192__B}
C {lab_pin.sym} 7450 3240 0 0 {name=l1573 sig_type=std_logic lab=_192__B}
N 7490 3280 7450 3280 {lab=_192__C}
C {lab_pin.sym} 7450 3280 0 0 {name=l1575 sig_type=std_logic lab=_192__C}
N 7610 3240 7650 3240 {lab=_266__D}
C {lab_pin.sym} 7650 3240 0 1 {name=l1577 sig_type=std_logic lab=_266__D}
C {sg13cmos5l_tiehi.sym} 670 3360 0 0 {name=X_282__103 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 3360 630 3360 {lab=_282__RESET_B}
C {lab_pin.sym} 630 3360 0 0 {name=l1580 sig_type=std_logic lab=_282__RESET_B}
C {sg13cmos5l_nor2b_1.sym} 1350 3380 0 0 {name=X_175_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 3360 1250 3360 {lab=_260__Q}
C {lab_pin.sym} 1250 3360 0 0 {name=l1583 sig_type=std_logic lab=_260__Q}
N 1290 3400 1250 3400 {lab=_176__A}
C {lab_pin.sym} 1250 3400 0 0 {name=l1585 sig_type=std_logic lab=_176__A}
N 1410 3380 1450 3380 {lab=_177__B}
C {lab_pin.sym} 1450 3380 0 1 {name=l1587 sig_type=std_logic lab=_177__B}
C {sg13cmos5l_nor2b_1.sym} 1970 3380 0 0 {name=X_244_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 3360 1870 3360 {lab=_244__A}
C {lab_pin.sym} 1870 3360 0 0 {name=l1590 sig_type=std_logic lab=_244__A}
N 1910 3400 1870 3400 {lab=_245__A}
C {lab_pin.sym} 1870 3400 0 0 {name=l1592 sig_type=std_logic lab=_245__A}
N 2030 3380 2070 3380 {lab=_246__B}
C {lab_pin.sym} 2070 3380 0 1 {name=l1594 sig_type=std_logic lab=_246__B}
C {sg13cmos5l_inv_1.sym} 2570 3360 0 0 {name=X_158_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 3360 2490 3360 {lab=_257__Q}
C {lab_pin.sym} 2490 3360 0 0 {name=l1597 sig_type=std_logic lab=_257__Q}
N 2610 3360 2650 3360 {lab=_158__Y}
C {lab_pin.sym} 2650 3360 0 1 {name=l1599 sig_type=std_logic lab=_158__Y}
C {sg13cmos5l_nor2_1.sym} 3210 3380 0 0 {name=X_227_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 3360 3110 3360 {lab=_233__A}
C {lab_pin.sym} 3110 3360 0 0 {name=l1602 sig_type=std_logic lab=_233__A}
N 3150 3400 3110 3400 {lab=_227__B}
C {lab_pin.sym} 3110 3400 0 0 {name=l1604 sig_type=std_logic lab=_227__B}
N 3270 3380 3310 3380 {lab=_228__C}
C {lab_pin.sym} 3310 3380 0 1 {name=l1606 sig_type=std_logic lab=_228__C}
C {sg13cmos5l_dfrbpq_1.sym} 3860 3380 0 0 {name=X_260_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 3360 3730 3360 {lab=clk}
C {lab_pin.sym} 3730 3360 0 0 {name=l1609 sig_type=std_logic lab=clk}
N 3770 3380 3730 3380 {lab=_260__D}
C {lab_pin.sym} 3730 3380 0 0 {name=l1611 sig_type=std_logic lab=_260__D}
N 3770 3400 3730 3400 {lab=_260__RESET_B}
C {lab_pin.sym} 3730 3400 0 0 {name=l1613 sig_type=std_logic lab=_260__RESET_B}
N 3950 3360 3990 3360 {lab=_260__Q}
C {lab_pin.sym} 3990 3360 0 1 {name=l1615 sig_type=std_logic lab=_260__Q}
C {sg13cmos5l_nor2_1.sym} 4450 3380 0 0 {name=X_191_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 3360 4350 3360 {lab=_191__A}
C {lab_pin.sym} 4350 3360 0 0 {name=l1618 sig_type=std_logic lab=_191__A}
N 4390 3400 4350 3400 {lab=_191__B}
C {lab_pin.sym} 4350 3400 0 0 {name=l1620 sig_type=std_logic lab=_191__B}
N 4510 3380 4550 3380 {lab=_192__C}
C {lab_pin.sym} 4550 3380 0 1 {name=l1622 sig_type=std_logic lab=_192__C}
C {sg13cmos5l_nor3_1.sym} 5070 3400 0 0 {name=X_243_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 3360 4970 3360 {lab=_243__A}
C {lab_pin.sym} 4970 3360 0 0 {name=l1625 sig_type=std_logic lab=_243__A}
N 5010 3400 4970 3400 {lab=_243__B}
C {lab_pin.sym} 4970 3400 0 0 {name=l1627 sig_type=std_logic lab=_243__B}
N 5010 3440 4970 3440 {lab=_243__C}
C {lab_pin.sym} 4970 3440 0 0 {name=l1629 sig_type=std_logic lab=_243__C}
N 5130 3400 5170 3400 {lab=_283__D}
C {lab_pin.sym} 5170 3400 0 1 {name=l1631 sig_type=std_logic lab=_283__D}
C {sg13cmos5l_nor3_1.sym} 5690 3400 0 0 {name=X_174_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 3360 5590 3360 {lab=_195__A}
C {lab_pin.sym} 5590 3360 0 0 {name=l1634 sig_type=std_logic lab=_195__A}
N 5630 3400 5590 3400 {lab=_174__B}
C {lab_pin.sym} 5590 3400 0 0 {name=l1636 sig_type=std_logic lab=_174__B}
N 5630 3440 5590 3440 {lab=_174__C}
C {lab_pin.sym} 5590 3440 0 0 {name=l1638 sig_type=std_logic lab=_174__C}
N 5750 3400 5790 3400 {lab=_174__Y}
C {lab_pin.sym} 5790 3400 0 1 {name=l1640 sig_type=std_logic lab=_174__Y}
C {sg13cmos5l_inv_1.sym} 6290 3360 0 0 {name=X_157_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 3360 6210 3360 {lab=_258__Q}
C {lab_pin.sym} 6210 3360 0 0 {name=l1643 sig_type=std_logic lab=_258__Q}
N 6330 3360 6370 3360 {lab=_157__Y}
C {lab_pin.sym} 6370 3360 0 1 {name=l1645 sig_type=std_logic lab=_157__Y}
C {sg13cmos5l_nor2b_1.sym} 6930 3380 0 0 {name=X_226_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 3360 6830 3360 {lab=_226__A}
C {lab_pin.sym} 6830 3360 0 0 {name=l1648 sig_type=std_logic lab=_226__A}
N 6870 3400 6830 3400 {lab=_233__A}
C {lab_pin.sym} 6830 3400 0 0 {name=l1650 sig_type=std_logic lab=_233__A}
N 6990 3380 7030 3380 {lab=_228__B}
C {lab_pin.sym} 7030 3380 0 1 {name=l1652 sig_type=std_logic lab=_228__B}
C {sg13cmos5l_nor2_1.sym} 7550 3380 0 0 {name=X_209_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 3360 7450 3360 {lab=_215__A}
C {lab_pin.sym} 7450 3360 0 0 {name=l1655 sig_type=std_logic lab=_215__A}
N 7490 3400 7450 3400 {lab=_209__B}
C {lab_pin.sym} 7450 3400 0 0 {name=l1657 sig_type=std_logic lab=_209__B}
N 7610 3380 7650 3380 {lab=_210__C}
C {lab_pin.sym} 7650 3380 0 1 {name=l1659 sig_type=std_logic lab=_210__C}
C {sg13cmos5l_nor2b_1.sym} 730 3540 0 0 {name=X_190_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 3520 630 3520 {lab=_190__A}
C {lab_pin.sym} 630 3520 0 0 {name=l1662 sig_type=std_logic lab=_190__A}
N 670 3560 630 3560 {lab=_191__A}
C {lab_pin.sym} 630 3560 0 0 {name=l1664 sig_type=std_logic lab=_191__A}
N 790 3540 830 3540 {lab=_192__B}
C {lab_pin.sym} 830 3540 0 1 {name=l1666 sig_type=std_logic lab=_192__B}
C {sg13cmos5l_tiehi.sym} 1290 3520 0 0 {name=X_265__98 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 3520 1250 3520 {lab=_265__98_L_HI}
C {lab_pin.sym} 1250 3520 0 0 {name=l1669 sig_type=std_logic lab=_265__98_L_HI}
C {sg13cmos5l_nor2_1.sym} 1970 3540 0 0 {name=X_173_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 3520 1870 3520 {lab=_176__A}
C {lab_pin.sym} 1870 3520 0 0 {name=l1672 sig_type=std_logic lab=_176__A}
N 1910 3560 1870 3560 {lab=_173__B}
C {lab_pin.sym} 1870 3560 0 0 {name=l1674 sig_type=std_logic lab=_173__B}
N 2030 3540 2070 3540 {lab=_174__C}
C {lab_pin.sym} 2070 3540 0 1 {name=l1676 sig_type=std_logic lab=_174__C}
C {sg13cmos5l_nor2_1.sym} 2590 3540 0 0 {name=X_242_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 3520 2490 3520 {lab=_245__A}
C {lab_pin.sym} 2490 3520 0 0 {name=l1679 sig_type=std_logic lab=_245__A}
N 2530 3560 2490 3560 {lab=_244__A}
C {lab_pin.sym} 2490 3560 0 0 {name=l1681 sig_type=std_logic lab=_244__A}
N 2650 3540 2690 3540 {lab=_243__C}
C {lab_pin.sym} 2690 3540 0 1 {name=l1683 sig_type=std_logic lab=_243__C}
C {sg13cmos5l_inv_1.sym} 3190 3520 0 0 {name=X_156_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 3520 3110 3520 {lab=_259__Q}
C {lab_pin.sym} 3110 3520 0 0 {name=l1686 sig_type=std_logic lab=_259__Q}
N 3230 3520 3270 3520 {lab=_156__Y}
C {lab_pin.sym} 3270 3520 0 1 {name=l1688 sig_type=std_logic lab=_156__Y}
C {sg13cmos5l_nor3_1.sym} 3830 3560 0 0 {name=X_225_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 3520 3730 3520 {lab=_243__A}
C {lab_pin.sym} 3730 3520 0 0 {name=l1691 sig_type=std_logic lab=_243__A}
N 3770 3560 3730 3560 {lab=_225__B}
C {lab_pin.sym} 3730 3560 0 0 {name=l1693 sig_type=std_logic lab=_225__B}
N 3770 3600 3730 3600 {lab=_225__C}
C {lab_pin.sym} 3730 3600 0 0 {name=l1695 sig_type=std_logic lab=_225__C}
N 3890 3560 3930 3560 {lab=_225__Y}
C {lab_pin.sym} 3930 3560 0 1 {name=l1697 sig_type=std_logic lab=_225__Y}
C {sg13cmos5l_nor2b_1.sym} 4450 3540 0 0 {name=X_208_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 3520 4350 3520 {lab=_271__Q}
C {lab_pin.sym} 4350 3520 0 0 {name=l1700 sig_type=std_logic lab=_271__Q}
N 4390 3560 4350 3560 {lab=_215__A}
C {lab_pin.sym} 4350 3560 0 0 {name=l1702 sig_type=std_logic lab=_215__A}
N 4510 3540 4550 3540 {lab=_210__B}
C {lab_pin.sym} 4550 3540 0 1 {name=l1704 sig_type=std_logic lab=_210__B}
C {sg13cmos5l_inv_1.sym} 5050 3520 0 0 {name=X_139_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 3520 4970 3520 {lab=_276__Q}
C {lab_pin.sym} 4970 3520 0 0 {name=l1707 sig_type=std_logic lab=_276__Q}
N 5090 3520 5130 3520 {lab=_139__Y}
C {lab_pin.sym} 5130 3520 0 1 {name=l1709 sig_type=std_logic lab=_139__Y}
C {sg13cmos5l_nor2b_1.sym} 5690 3540 0 0 {name=X_172_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 3520 5590 3520 {lab=_259__Q}
C {lab_pin.sym} 5590 3520 0 0 {name=l1712 sig_type=std_logic lab=_259__Q}
N 5630 3560 5590 3560 {lab=_176__A}
C {lab_pin.sym} 5590 3560 0 0 {name=l1714 sig_type=std_logic lab=_176__A}
N 5750 3540 5790 3540 {lab=_174__B}
C {lab_pin.sym} 5790 3540 0 1 {name=l1716 sig_type=std_logic lab=_174__B}
C {sg13cmos5l_nor2b_1.sym} 6310 3540 0 0 {name=X_241_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 3520 6210 3520 {lab=_241__A}
C {lab_pin.sym} 6210 3520 0 0 {name=l1719 sig_type=std_logic lab=_241__A}
N 6250 3560 6210 3560 {lab=_245__A}
C {lab_pin.sym} 6210 3560 0 0 {name=l1721 sig_type=std_logic lab=_245__A}
N 6370 3540 6410 3540 {lab=_243__B}
C {lab_pin.sym} 6410 3540 0 1 {name=l1723 sig_type=std_logic lab=_243__B}
C {sg13cmos5l_inv_1.sym} 6910 3520 0 0 {name=X_155_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 3520 6830 3520 {lab=_260__Q}
C {lab_pin.sym} 6830 3520 0 0 {name=l1726 sig_type=std_logic lab=_260__Q}
N 6950 3520 6990 3520 {lab=_155__Y}
C {lab_pin.sym} 6990 3520 0 1 {name=l1728 sig_type=std_logic lab=_155__Y}
C {sg13cmos5l_nor2_1.sym} 7550 3540 0 0 {name=X_224_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 3520 7450 3520 {lab=_224__A}
C {lab_pin.sym} 7450 3520 0 0 {name=l1731 sig_type=std_logic lab=_224__A}
N 7490 3560 7450 3560 {lab=_226__A}
C {lab_pin.sym} 7450 3560 0 0 {name=l1733 sig_type=std_logic lab=_226__A}
N 7610 3540 7650 3540 {lab=_225__C}
C {lab_pin.sym} 7650 3540 0 1 {name=l1735 sig_type=std_logic lab=_225__C}
C {sg13cmos5l_nor3_1.sym} 730 3720 0 0 {name=X_207_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 3680 630 3680 {lab=_213__A}
C {lab_pin.sym} 630 3680 0 0 {name=l1738 sig_type=std_logic lab=_213__A}
N 670 3720 630 3720 {lab=_207__B}
C {lab_pin.sym} 630 3720 0 0 {name=l1740 sig_type=std_logic lab=_207__B}
N 670 3760 630 3760 {lab=_207__C}
C {lab_pin.sym} 630 3760 0 0 {name=l1742 sig_type=std_logic lab=_207__C}
N 790 3720 830 3720 {lab=_271__D}
C {lab_pin.sym} 830 3720 0 1 {name=l1744 sig_type=std_logic lab=_271__D}
C {sg13cmos5l_inv_1.sym} 1330 3680 0 0 {name=X_138_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 3680 1250 3680 {lab=_277__Q}
C {lab_pin.sym} 1250 3680 0 0 {name=l1747 sig_type=std_logic lab=_277__Q}
N 1370 3680 1410 3680 {lab=_138__Y}
C {lab_pin.sym} 1410 3680 0 1 {name=l1749 sig_type=std_logic lab=_138__Y}
C {sg13cmos5l_tiehi.sym} 1910 3680 0 0 {name=X_262__104 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 3680 1870 3680 {lab=_262__RESET_B}
C {lab_pin.sym} 1870 3680 0 0 {name=l1752 sig_type=std_logic lab=_262__RESET_B}
C {sg13cmos5l_tiehi.sym} 2530 3680 0 0 {name=X_277__97 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 3680 2490 3680 {lab=_277__97_L_HI}
C {lab_pin.sym} 2490 3680 0 0 {name=l1755 sig_type=std_logic lab=_277__97_L_HI}
C {sg13cmos5l_nor3_1.sym} 3210 3720 0 0 {name=X_240_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 3680 3110 3680 {lab=_252__A}
C {lab_pin.sym} 3110 3680 0 0 {name=l1758 sig_type=std_logic lab=_252__A}
N 3150 3720 3110 3720 {lab=_240__B}
C {lab_pin.sym} 3110 3720 0 0 {name=l1760 sig_type=std_logic lab=_240__B}
N 3150 3760 3110 3760 {lab=_240__C}
C {lab_pin.sym} 3110 3760 0 0 {name=l1762 sig_type=std_logic lab=_240__C}
N 3270 3720 3310 3720 {lab=_240__Y}
C {lab_pin.sym} 3310 3720 0 1 {name=l1764 sig_type=std_logic lab=_240__Y}
C {sg13cmos5l_nor3_1.sym} 3830 3720 0 0 {name=X_171_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 3680 3730 3680 {lab=_195__A}
C {lab_pin.sym} 3730 3680 0 0 {name=l1767 sig_type=std_logic lab=_195__A}
N 3770 3720 3730 3720 {lab=_171__B}
C {lab_pin.sym} 3730 3720 0 0 {name=l1769 sig_type=std_logic lab=_171__B}
N 3770 3760 3730 3760 {lab=_171__C}
C {lab_pin.sym} 3730 3760 0 0 {name=l1771 sig_type=std_logic lab=_171__C}
N 3890 3720 3930 3720 {lab=_171__Y}
C {lab_pin.sym} 3930 3720 0 1 {name=l1773 sig_type=std_logic lab=_171__Y}
C {sg13cmos5l_nor2b_1.sym} 4450 3700 0 0 {name=X_223_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 3680 4350 3680 {lab=_276__Q}
C {lab_pin.sym} 4350 3680 0 0 {name=l1776 sig_type=std_logic lab=_276__Q}
N 4390 3720 4350 3720 {lab=_224__A}
C {lab_pin.sym} 4350 3720 0 0 {name=l1778 sig_type=std_logic lab=_224__A}
N 4510 3700 4550 3700 {lab=_225__B}
C {lab_pin.sym} 4550 3700 0 1 {name=l1780 sig_type=std_logic lab=_225__B}
C {sg13cmos5l_inv_1.sym} 5050 3680 0 0 {name=X_154_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 3680 4970 3680 {lab=_261__Q}
C {lab_pin.sym} 4970 3680 0 0 {name=l1783 sig_type=std_logic lab=_261__Q}
N 5090 3680 5130 3680 {lab=_154__Y}
C {lab_pin.sym} 5130 3680 0 1 {name=l1785 sig_type=std_logic lab=_154__Y}
C {sg13cmos5l_decap_8.sym} 5670 3700 0 0 {name=XFILLER_6_145 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
C {sg13cmos5l_inv_1.sym} 6290 3680 0 0 {name=X_137_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 3680 6210 3680 {lab=_278__Q}
C {lab_pin.sym} 6210 3680 0 0 {name=l1789 sig_type=std_logic lab=_278__Q}
N 6330 3680 6370 3680 {lab=_137__Y}
C {lab_pin.sym} 6370 3680 0 1 {name=l1791 sig_type=std_logic lab=_137__Y}
C {sg13cmos5l_nor2_1.sym} 6930 3700 0 0 {name=X_206_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 3680 6830 3680 {lab=_206__A}
C {lab_pin.sym} 6830 3680 0 0 {name=l1794 sig_type=std_logic lab=_206__A}
N 6870 3720 6830 3720 {lab=_206__B}
C {lab_pin.sym} 6830 3720 0 0 {name=l1796 sig_type=std_logic lab=_206__B}
N 6990 3700 7030 3700 {lab=_207__C}
C {lab_pin.sym} 7030 3700 0 1 {name=l1798 sig_type=std_logic lab=_207__C}
C {sg13cmos5l_nor2_1.sym} 7550 3700 0 0 {name=X_170_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 3680 7450 3680 {lab=_176__A}
C {lab_pin.sym} 7450 3680 0 0 {name=l1801 sig_type=std_logic lab=_176__A}
N 7490 3720 7450 3720 {lab=_259__Q}
C {lab_pin.sym} 7450 3720 0 0 {name=l1803 sig_type=std_logic lab=_259__Q}
N 7610 3700 7650 3700 {lab=_171__C}
C {lab_pin.sym} 7650 3700 0 1 {name=l1805 sig_type=std_logic lab=_171__C}
C {sg13cmos5l_inv_1.sym} 710 3840 0 0 {name=X_153_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 3840 630 3840 {lab=_262__Q}
C {lab_pin.sym} 630 3840 0 0 {name=l1808 sig_type=std_logic lab=_262__Q}
N 750 3840 790 3840 {lab=_153__Y}
C {lab_pin.sym} 790 3840 0 1 {name=l1810 sig_type=std_logic lab=_153__Y}
C {sg13cmos5l_nor3_1.sym} 1350 3880 0 0 {name=X_222_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 3840 1250 3840 {lab=_243__A}
C {lab_pin.sym} 1250 3840 0 0 {name=l1813 sig_type=std_logic lab=_243__A}
N 1290 3880 1250 3880 {lab=_222__B}
C {lab_pin.sym} 1250 3880 0 0 {name=l1815 sig_type=std_logic lab=_222__B}
N 1290 3920 1250 3920 {lab=_222__C}
C {lab_pin.sym} 1250 3920 0 0 {name=l1817 sig_type=std_logic lab=_222__C}
N 1410 3880 1450 3880 {lab=_276__D}
C {lab_pin.sym} 1450 3880 0 1 {name=l1819 sig_type=std_logic lab=_276__D}
C {sg13cmos5l_nor2b_1.sym} 1970 3860 0 0 {name=X_205_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 3840 1870 3840 {lab=_205__A}
C {lab_pin.sym} 1870 3840 0 0 {name=l1822 sig_type=std_logic lab=_205__A}
N 1910 3880 1870 3880 {lab=_206__A}
C {lab_pin.sym} 1870 3880 0 0 {name=l1824 sig_type=std_logic lab=_206__A}
N 2030 3860 2070 3860 {lab=_207__B}
C {lab_pin.sym} 2070 3860 0 1 {name=l1826 sig_type=std_logic lab=_207__B}
C {sg13cmos5l_inv_1.sym} 2570 3840 0 0 {name=X_136_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 3840 2490 3840 {lab=_279__Q}
C {lab_pin.sym} 2490 3840 0 0 {name=l1829 sig_type=std_logic lab=_279__Q}
N 2610 3840 2650 3840 {lab=_136__Y}
C {lab_pin.sym} 2650 3840 0 1 {name=l1831 sig_type=std_logic lab=_136__Y}
C {sg13cmos5l_tiehi.sym} 3150 3840 0 0 {name=X_275__105 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 3840 3110 3840 {lab=_275__RESET_B}
C {lab_pin.sym} 3110 3840 0 0 {name=l1834 sig_type=std_logic lab=_275__RESET_B}
C {sg13cmos5l_inv_1.sym} 3810 3840 0 0 {name=X_152_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 3840 3730 3840 {lab=_263__Q}
C {lab_pin.sym} 3730 3840 0 0 {name=l1837 sig_type=std_logic lab=_263__Q}
N 3850 3840 3890 3840 {lab=_152__Y}
C {lab_pin.sym} 3890 3840 0 1 {name=l1839 sig_type=std_logic lab=_152__Y}
C {sg13cmos5l_nor2_1.sym} 4450 3860 0 0 {name=X_221_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 3840 4350 3840 {lab=_224__A}
C {lab_pin.sym} 4350 3840 0 0 {name=l1842 sig_type=std_logic lab=_224__A}
N 4390 3880 4350 3880 {lab=_221__B}
C {lab_pin.sym} 4350 3880 0 0 {name=l1844 sig_type=std_logic lab=_221__B}
N 4510 3860 4550 3860 {lab=_222__C}
C {lab_pin.sym} 4550 3860 0 1 {name=l1846 sig_type=std_logic lab=_222__C}
C {sg13cmos5l_nor3_1.sym} 5070 3880 0 0 {name=X_204_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 3840 4970 3840 {lab=_213__A}
C {lab_pin.sym} 4970 3840 0 0 {name=l1849 sig_type=std_logic lab=_213__A}
N 5010 3880 4970 3880 {lab=_204__B}
C {lab_pin.sym} 4970 3880 0 0 {name=l1851 sig_type=std_logic lab=_204__B}
N 5010 3920 4970 3920 {lab=_204__C}
C {lab_pin.sym} 4970 3920 0 0 {name=l1853 sig_type=std_logic lab=_204__C}
N 5130 3880 5170 3880 {lab=_270__D}
C {lab_pin.sym} 5170 3880 0 1 {name=l1855 sig_type=std_logic lab=_270__D}
C {sg13cmos5l_inv_1.sym} 5670 3840 0 0 {name=X_135_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 3840 5590 3840 {lab=_280__Q}
C {lab_pin.sym} 5590 3840 0 0 {name=l1858 sig_type=std_logic lab=_280__Q}
N 5710 3840 5750 3840 {lab=_135__Y}
C {lab_pin.sym} 5750 3840 0 1 {name=l1860 sig_type=std_logic lab=_135__Y}
C {sg13cmos5l_tiehi.sym} 6250 3840 0 0 {name=X_285__107 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 3840 6210 3840 {lab=_285__RESET_B}
C {lab_pin.sym} 6210 3840 0 0 {name=l1863 sig_type=std_logic lab=_285__RESET_B}
C {sg13cmos5l_buf_1.sym} 6910 3840 0 0 {name=Xoutput60 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 3840 6830 3840 {lab=_141__Y}
C {lab_pin.sym} 6830 3840 0 0 {name=l1866 sig_type=std_logic lab=_141__Y}
N 6950 3840 6990 3840 {lab=q_bar[31]}
C {lab_pin.sym} 6990 3840 0 1 {name=l1868 sig_type=std_logic lab=q_bar[31]}
C {sg13cmos5l_tiehi.sym} 7490 3840 0 0 {name=X_258__112 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 3840 7450 3840 {lab=_258__RESET_B}
C {lab_pin.sym} 7450 3840 0 0 {name=l1871 sig_type=std_logic lab=_258__RESET_B}
C {sg13cmos5l_inv_1.sym} 710 4000 0 0 {name=X_151_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 4000 630 4000 {lab=_264__Q}
C {lab_pin.sym} 630 4000 0 0 {name=l1874 sig_type=std_logic lab=_264__Q}
N 750 4000 790 4000 {lab=_151__Y}
C {lab_pin.sym} 790 4000 0 1 {name=l1876 sig_type=std_logic lab=_151__Y}
C {sg13cmos5l_nor2b_1.sym} 1350 4020 0 0 {name=X_220_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 4000 1250 4000 {lab=_220__A}
C {lab_pin.sym} 1250 4000 0 0 {name=l1879 sig_type=std_logic lab=_220__A}
N 1290 4040 1250 4040 {lab=_224__A}
C {lab_pin.sym} 1250 4040 0 0 {name=l1881 sig_type=std_logic lab=_224__A}
N 1410 4020 1450 4020 {lab=_222__B}
C {lab_pin.sym} 1450 4020 0 1 {name=l1883 sig_type=std_logic lab=_222__B}
C {sg13cmos5l_inv_1.sym} 1950 4000 0 0 {name=X_134_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 4000 1870 4000 {lab=_281__Q}
C {lab_pin.sym} 1870 4000 0 0 {name=l1886 sig_type=std_logic lab=_281__Q}
N 1990 4000 2030 4000 {lab=_134__Y}
C {lab_pin.sym} 2030 4000 0 1 {name=l1888 sig_type=std_logic lab=_134__Y}
C {sg13cmos5l_nor2_1.sym} 2590 4020 0 0 {name=X_203_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 4000 2490 4000 {lab=_206__A}
C {lab_pin.sym} 2490 4000 0 0 {name=l1891 sig_type=std_logic lab=_206__A}
N 2530 4040 2490 4040 {lab=_205__A}
C {lab_pin.sym} 2490 4040 0 0 {name=l1893 sig_type=std_logic lab=_205__A}
N 2650 4020 2690 4020 {lab=_204__C}
C {lab_pin.sym} 2690 4020 0 1 {name=l1895 sig_type=std_logic lab=_204__C}
C {sg13cmos5l_buf_1.sym} 3190 4000 0 0 {name=Xoutput50 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 4000 3110 4000 {lab=_150__Y}
C {lab_pin.sym} 3110 4000 0 0 {name=l1898 sig_type=std_logic lab=_150__Y}
N 3230 4000 3270 4000 {lab=q_bar[22]}
C {lab_pin.sym} 3270 4000 0 1 {name=l1900 sig_type=std_logic lab=q_bar[22]}
C {sg13cmos5l_buf_1.sym} 3810 4000 0 0 {name=Xoutput61 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 4000 3730 4000 {lab=_137__Y}
C {lab_pin.sym} 3730 4000 0 0 {name=l1903 sig_type=std_logic lab=_137__Y}
N 3850 4000 3890 4000 {lab=q_bar[3]}
C {lab_pin.sym} 3890 4000 0 1 {name=l1905 sig_type=std_logic lab=q_bar[3]}
C {sg13cmos5l_buf_1.sym} 4430 4000 0 0 {name=Xoutput4 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 4000 4350 4000 {lab=_275__Q}
C {lab_pin.sym} 4350 4000 0 0 {name=l1908 sig_type=std_logic lab=_275__Q}
N 4470 4000 4510 4000 {lab=q[0]}
C {lab_pin.sym} 4510 4000 0 1 {name=l1910 sig_type=std_logic lab=q[0]}
C {sg13cmos5l_tiehi.sym} 5010 4000 0 0 {name=X_281__111 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 4000 4970 4000 {lab=_281__RESET_B}
C {lab_pin.sym} 4970 4000 0 0 {name=l1913 sig_type=std_logic lab=_281__RESET_B}
C {sg13cmos5l_decap_8.sym} 5670 4020 0 0 {name=XFILLER_6_138 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
C {sg13cmos5l_inv_1.sym} 6290 4000 0 0 {name=X_150_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 4000 6210 4000 {lab=_265__Q}
C {lab_pin.sym} 6210 4000 0 0 {name=l1917 sig_type=std_logic lab=_265__Q}
N 6330 4000 6370 4000 {lab=_150__Y}
C {lab_pin.sym} 6370 4000 0 1 {name=l1919 sig_type=std_logic lab=_150__Y}
C {sg13cmos5l_dfrbpq_1.sym} 6960 4020 0 0 {name=X_279_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 4000 6830 4000 {lab=clk}
C {lab_pin.sym} 6830 4000 0 0 {name=l1922 sig_type=std_logic lab=clk}
N 6870 4020 6830 4020 {lab=_279__D}
C {lab_pin.sym} 6830 4020 0 0 {name=l1924 sig_type=std_logic lab=_279__D}
N 6870 4040 6830 4040 {lab=_279__89_L_HI}
C {lab_pin.sym} 6830 4040 0 0 {name=l1926 sig_type=std_logic lab=_279__89_L_HI}
N 7050 4000 7090 4000 {lab=_279__Q}
C {lab_pin.sym} 7090 4000 0 1 {name=l1928 sig_type=std_logic lab=_279__Q}
C {sg13cmos5l_nor2b_1.sym} 7550 4020 0 0 {name=X_202_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 4000 7450 4000 {lab=_202__A}
C {lab_pin.sym} 7450 4000 0 0 {name=l1931 sig_type=std_logic lab=_202__A}
N 7490 4040 7450 4040 {lab=_215__A}
C {lab_pin.sym} 7450 4040 0 0 {name=l1933 sig_type=std_logic lab=_215__A}
N 7610 4020 7650 4020 {lab=_204__B}
C {lab_pin.sym} 7650 4020 0 1 {name=l1935 sig_type=std_logic lab=_204__B}
C {sg13cmos5l_inv_1.sym} 710 4160 0 0 {name=X_133_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 4160 630 4160 {lab=_282__Q}
C {lab_pin.sym} 630 4160 0 0 {name=l1938 sig_type=std_logic lab=_282__Q}
N 750 4160 790 4160 {lab=_133__Y}
C {lab_pin.sym} 790 4160 0 1 {name=l1940 sig_type=std_logic lab=_133__Y}
C {sg13cmos5l_buf_1.sym} 1330 4160 0 0 {name=Xoutput51 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1290 4160 1250 4160 {lab=_149__Y}
C {lab_pin.sym} 1250 4160 0 0 {name=l1943 sig_type=std_logic lab=_149__Y}
N 1370 4160 1410 4160 {lab=q_bar[23]}
C {lab_pin.sym} 1410 4160 0 1 {name=l1945 sig_type=std_logic lab=q_bar[23]}
C {sg13cmos5l_buf_1.sym} 1950 4160 0 0 {name=Xoutput40 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 1910 4160 1870 4160 {lab=_159__Y}
C {lab_pin.sym} 1870 4160 0 0 {name=l1948 sig_type=std_logic lab=_159__Y}
N 1990 4160 2030 4160 {lab=q_bar[13]}
C {lab_pin.sym} 2030 4160 0 1 {name=l1950 sig_type=std_logic lab=q_bar[13]}
C {sg13cmos5l_buf_1.sym} 2570 4160 0 0 {name=Xoutput5 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 2530 4160 2490 4160 {lab=_285__Q}
C {lab_pin.sym} 2490 4160 0 0 {name=l1953 sig_type=std_logic lab=_285__Q}
N 2610 4160 2650 4160 {lab=q[10]}
C {lab_pin.sym} 2650 4160 0 1 {name=l1955 sig_type=std_logic lab=q[10]}
C {sg13cmos5l_buf_1.sym} 3190 4160 0 0 {name=Xoutput62 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3150 4160 3110 4160 {lab=_136__Y}
C {lab_pin.sym} 3110 4160 0 0 {name=l1958 sig_type=std_logic lab=_136__Y}
N 3230 4160 3270 4160 {lab=q_bar[4]}
C {lab_pin.sym} 3270 4160 0 1 {name=l1960 sig_type=std_logic lab=q_bar[4]}
C {sg13cmos5l_dfrbpq_1.sym} 3860 4180 0 0 {name=X_278_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 3770 4160 3730 4160 {lab=clk}
C {lab_pin.sym} 3730 4160 0 0 {name=l1963 sig_type=std_logic lab=clk}
N 3770 4180 3730 4180 {lab=_278__D}
C {lab_pin.sym} 3730 4180 0 0 {name=l1965 sig_type=std_logic lab=_278__D}
N 3770 4200 3730 4200 {lab=_278__93_L_HI}
C {lab_pin.sym} 3730 4200 0 0 {name=l1967 sig_type=std_logic lab=_278__93_L_HI}
N 3950 4160 3990 4160 {lab=_278__Q}
C {lab_pin.sym} 3990 4160 0 1 {name=l1969 sig_type=std_logic lab=_278__Q}
C {sg13cmos5l_inv_1.sym} 4430 4160 0 0 {name=X_132_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 4390 4160 4350 4160 {lab=_283__Q}
C {lab_pin.sym} 4350 4160 0 0 {name=l1972 sig_type=std_logic lab=_283__Q}
N 4470 4160 4510 4160 {lab=_132__Y}
C {lab_pin.sym} 4510 4160 0 1 {name=l1974 sig_type=std_logic lab=_132__Y}
C {sg13cmos5l_nor3_1.sym} 5070 4200 0 0 {name=X_201_ VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5010 4160 4970 4160 {lab=_213__A}
C {lab_pin.sym} 4970 4160 0 0 {name=l1977 sig_type=std_logic lab=_213__A}
N 5010 4200 4970 4200 {lab=_201__B}
C {lab_pin.sym} 4970 4200 0 0 {name=l1979 sig_type=std_logic lab=_201__B}
N 5010 4240 4970 4240 {lab=_201__C}
C {lab_pin.sym} 4970 4240 0 0 {name=l1981 sig_type=std_logic lab=_201__C}
N 5130 4200 5170 4200 {lab=_201__Y}
C {lab_pin.sym} 5170 4200 0 1 {name=l1983 sig_type=std_logic lab=_201__Y}
C {sg13cmos5l_buf_1.sym} 5670 4160 0 0 {name=Xoutput41 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 5630 4160 5590 4160 {lab=_158__Y}
C {lab_pin.sym} 5590 4160 0 0 {name=l1986 sig_type=std_logic lab=_158__Y}
N 5710 4160 5750 4160 {lab=q_bar[14]}
C {lab_pin.sym} 5750 4160 0 1 {name=l1988 sig_type=std_logic lab=q_bar[14]}
C {sg13cmos5l_buf_1.sym} 6290 4160 0 0 {name=Xoutput6 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6250 4160 6210 4160 {lab=_286__Q}
C {lab_pin.sym} 6210 4160 0 0 {name=l1991 sig_type=std_logic lab=_286__Q}
N 6330 4160 6370 4160 {lab=q[11]}
C {lab_pin.sym} 6370 4160 0 1 {name=l1993 sig_type=std_logic lab=q[11]}
C {sg13cmos5l_buf_1.sym} 6910 4160 0 0 {name=Xoutput30 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 6870 4160 6830 4160 {lab=_279__Q}
C {lab_pin.sym} 6830 4160 0 0 {name=l1996 sig_type=std_logic lab=_279__Q}
N 6950 4160 6990 4160 {lab=q[4]}
C {lab_pin.sym} 6990 4160 0 1 {name=l1998 sig_type=std_logic lab=q[4]}
C {sg13cmos5l_buf_1.sym} 7530 4160 0 0 {name=Xoutput52 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 7490 4160 7450 4160 {lab=_148__Y}
C {lab_pin.sym} 7450 4160 0 0 {name=l2001 sig_type=std_logic lab=_148__Y}
N 7570 4160 7610 4160 {lab=q_bar[24]}
C {lab_pin.sym} 7610 4160 0 1 {name=l2003 sig_type=std_logic lab=q_bar[24]}
C {sg13cmos5l_buf_1.sym} 710 4320 0 0 {name=Xoutput63 VDD=VPWR VSS=VGND prefix=sg13cmos5l_ }
N 670 4320 630 4320 {lab=_135__Y}
C {lab_pin.sym} 630 4320 0 0 {name=l2006 sig_type=std_logic lab=_135__Y}
N 750 4320 790 4320 {lab=q_bar[5]}
C {lab_pin.sym} 790 4320 0 1 {name=l2008 sig_type=std_logic lab=q_bar[5]}
